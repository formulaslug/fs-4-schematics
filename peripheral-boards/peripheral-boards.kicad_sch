File: peripheral-boards/peripheral-boards.kicad_sch (KiCad schematic)
At the start: 45 parts, among them J1 ATS668LSM, J10 Conn_01x26, J4 Strain Gauge, J8 FTSH-107-01-F-DV-K-P-TR, SW1 Y97KT23B5NAFP, SW5 A6H-4101, U1 SNG-SPRC-001, U2 INA125U, U3 STM32G441KBTx, U4 ISO1044DUB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

Commit message: Added blocks to all sensors and fixed main connector-working on footprints and notation
Parts:
- removed J1: ATS668LSM, Connector_Molex:Molex_Nano-Fit_105309-xx03_1x03_P2.50mm_Vertical, symbol Connector:Conn_01x03_Pin
- removed J4: Strain Gauge, Connector_Molex:Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical, symbol Connector:Conn_01x02_Pin
- added J1: ~, symbol FS_4_Global_Symbol_Library:ATS13-26PA-BM21
- added R13, R14: 10K, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, symbol Device:R
- added R15: R_Variable, symbol Device:R_Variable
- added R16, R17: 4.7k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R
- added Suspenison_travel1: ~, symbol FS_4_Global_Symbol_Library:suspenison_sense
- added TP1: PA4, TestPoint:TestPoint_Pad_D1.5mm, symbol Connector:TestPoint
- added TP2: PA6, TestPoint:TestPoint_Pad_D1.5mm, symbol Connector:TestPoint
- added TP3: PA10, TestPoint:TestPoint_Pad_D1.5mm, symbol Connector:TestPoint
- added TP4: PB4, TestPoint:TestPoint_Pad_D1.5mm, symbol Connector:TestPoint
- added TP5: PB6, TestPoint:TestPoint_Pad_D1.5mm, symbol Connector:TestPoint
- added TP6: PB7, TestPoint:TestPoint_Pad_D1.5mm, symbol Connector:TestPoint
- added U10: D6T-8L-09H, symbol FS_4_Global_Symbol_Library:D6T-8L-09H
- added U11: Tire Temp Sense, symbol FS_4_Global_Symbol_Library:D6T-8L-09H
- added U7: ~, symbol FS_4_Global_Symbol_Library:suspension_travel
- added U9: D6T-1A-02, symbol FS_4_Global_Symbol_Library:D6T-1A-02
- SW5: symbol FS_3_Global_Symbol_Library:A6H-4101 -> Switch:SW_DIP_x04
Connections:
- net +12V: now also J1.1, J1.9; no longer J10.1 (Pin_1)
- net +3V3: now also J1.12, U7. (GND); no longer J10.12 (Pin_12), J10.6 (Pin_6), U3.1 (VDD), U3.17 (VDD)
- net +3V3_A: no longer U3.15 (VDDA)
- net +5V: now also J1.15, J1.19, J1.23, R16.1, R17.1, U10. (GND), U11. (GND), U9. (GND); no longer J10.15 (Pin_15), J10.19 (Pin_19), J10.24 (Pin_24), J10.7 (Pin_7)
- net 1x1_TireTemp_Sensor_SCL: now also J1.17, R16.2, U10. (GND); no longer J10.17 (Pin_17)
- net 1x1_TireTemp_Sensor_SDA: now also U3.30 (PB7), J1.16, R17.2, U10. (GND); no longer J10.16 (Pin_16), U3.28 (PB5)
- net 1x8_TireTemp_Sensor_SCL: now also J1.25, U9. (GND); no longer J10.26 (Pin_26)
- net 1x8_TireTemp_Sensor_SDA: now also J1.24, U9. (GND); no longer J10.25 (Pin_25)
- net CANH: now also R4.2, J1.21, J1.3, U11. (GND); no longer J10.21 (Pin_21), J10.3 (Pin_3), SW5.4
- net CANL: now also SW5.3, J1.2, J1.20, U11. (GND); no longer J10.2 (Pin_2), J10.20 (Pin_20), R4.2
- net GND: now also J1.11, J1.14, J1.18, J1.22, J1.26, J1.4, R13.1, R14.1, U10. (GND), U11. (GND), U7. (GND), U9. (GND); no longer J10.10 (Pin_10), J10.14 (Pin_14), J10.22 (Pin_22), J10.23 (Pin_23), J10.4 (Pin_4), J10.8 (Pin_8)
- net SUSPENSION : now also J1.13 (1), U7. (GND); no longer J10.11 (Pin_11)
- net Vin+: now also J1.8, R15.2
- net Vrefout: now also J1.7, R15.1
- net wheel speed: no longer J10.13 (Pin_13)
- net Wheel_Speed_Out: now reaches R1.1, R2.1, U1.2 (OUT)
- net Wheel_Speed_Out: now also J1.10
- net at U3.11 (PA6): now also TP2.1
- net at U3.20 (PA10): now also TP3.1
- net at U3.27 (PB4): now also TP4.1
- net at U3.29 (PB6): now also TP5.1
- net at SW5.2, U3.5 (PA0): now also R13.2
- net at U3.6 (PA1): now also SW5.4, R14.2; no longer SW5.3
- net at U3.9 (PA4): now also TP1.1
- new net: TP6.1, U3.28 (PB5)
- no-connect marks 6 -> 8
Other:
- note added: "CHANGE PINS BASED ON ACTUAL CONNECTOR"
- note added: "Main Connector CANH"
- note added: "Main Connector CANL"
- note added: "Main Connector GND"
- note added: "Suspension Travel Block"
- note added: "Suspension Travel Sensor +3.3V"
- note added: "Tire Temp 1x8 Block"
- note added: "Wheel Speed +12V"
- note added: "Wheel Speed GND"
- note added: "Wheel speed sensor +12V"
- note added: "Wheel speed sensor GND"
- note added: "add pull ups"
- note added: "waiting for wesley on this so nothing i can do now"
- note removed: "(pins 6-8) i think this was the extra connector?"
- note removed: "Not on board"
- note removed: "Suspension Travel Sensor +5V"
- note removed: "Wheel Speed Sensor Connector"
- note removed: "merge gnd together"
- note removed: "pins 1-4 main connector"
- note removed: "pins 10-12 suspension travel sensor"
- note removed: "put this into the one big connector"
- moved on the sheet: J10, R4, R6, R8, U1, U3

Commit message: Edited sensor blocks and mock layout, not done
Parts:
- removed J10: Conn_01x26, symbol Connector_Generic:Conn_01x26
- J7: renamed from J1; value ~ -> Tire Temp Sensor; footprint (none) -> https://omronfs.omron.com/en_US/ecb/products/pdf/en_D6T_catalog.pdf
Connections:
- net +3V3: now also SW5.6
- net +5V: now also J1.18, J1.26, J7.22; no longer J1.15, J1.23, J7.19
- net GND: now also J1.15, J1.23, J7.19; no longer J1.18, J1.26, J7.22, SW5.6
Other:
- note added: "Extra Pins Connector"
- note added: "Sensor block"
- note added: "Suspension Travel GND"
- note added: "Suspension Travel OUT"
- note added: "Suspension Travle +3V3"
- note added: "Tire Surface Temp Sense GND"
- note added: "Tire Surface Temp Sense SCL"
- note added: "Tire Surface Temp Sense SDA"
- note added: "Tire Temp Sense CANH"
- note added: "Tire Temp Sense CANL"
- note added: "Tire Temp Sensor +5V"
- note added: "Tire Temp Sensor GND"
- note added: "Tire Temp Sensor SCL"
- note added: "Tire Temp Sensor SDA"
- note removed: "CHANGE PINS BASED ON ACTUAL CONNECTOR"
- note removed: "Main Connector +12V"
- note removed: "Main Connector CANH"
- note removed: "Main Connector CANL"
- note removed: "Main Connector GND"
- note removed: "Suspension Travel Sensor +3.3V"
- note removed: "Suspension Travel Sensor GND"
- note removed: "Tire Air Temp Sensor +5V"
- note removed: "Tire Air Temp Sensor GND"
- note removed: "Tire Surface Temp Sensor GND"
- note removed: "Wheel speed sensor +12V"
- note removed: "Wheel speed sensor GND"
- note removed: "add pull ups"
- note removed: "new big connector"
- note removed: "pins 14-17 tire air temp sensor"
- note removed: "pins 23-26 are tire surface temp sensor"
- moved on the sheet: C1, C2, C3, C4, C6, C8, C9, D1, J1A, J1C, J1D, J1E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

Commit message: Almost ready for layout
Parts:
- removed J7: Tire Temp Sensor, https://omronfs.omron.com/en_US/ecb/products/pdf/en_D6T_catalog.pdf, symbol FS_4_Global_Symbol_Library:ATS13-26PA-BM21
- removed U2: INA125U, Package_SO:SOIC-16_3.9x9.9mm_P1.27mm, symbol FS_4_Global_Symbol_Library:INA125U
- added C11, C19: 1uF, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, symbol Device:C
- added C12, C20, C21: 100nF, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, symbol Device:C
- added R18: 309R, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, symbol Device:R_US
- added U12: INA826AIDR, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, symbol Amplifier_Instrumentation:INA849D
- added U13: REF35160QDBVR, Package_TO_SOT_SMD:SOT-23-6, symbol Reference_Voltage:REF35160QDBVR
- C5, C6, C8, C9: footprint Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- D1: footprint Diode_SMD:D_0805_2012Metric_Pad1.15x1.40mm_HandSolder -> Diode_SMD:D_SMA; Digi URL (none) -> https://www.digikey.com/en/products/detail/diotec-semicondu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
- R1, R2, R3, R5: footprint Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R10: value Extra -> 16K; footprint Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R11: value 60.4R -> 16K; footprint Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R16, R17, R6, R8: footprint Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R4: value 120 -> 120R
- R7, R9: value 120R -> 360R; footprint Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- SW5: Digi PN (none) -> 39-A6H-4101-ND; Digikey Part Number 39-A6H-4101-ND -> (none)
- U11: value Tire Temp Sense -> Brake Temp Sense
- U7: value ~ -> Suspension Travel Sensor
Connections:
- net +3V3: now also C5.2, U3.1 (VDD), U3.17 (VDD), C12.1, U12.8 (Vs+), U13.3 (EN), U13.4 (VIN); no longer C5.1
- net +3V3_A: now also U3.15 (VDDA)
- net +5V: now also J1.19
- net CANH: now also J1.20
- net CANL: now also J1.21
- net GND: now also C5.1, J1.22, R7.1, C11.2, C12.2, C19.2, C20.2, C21.2, U12.5 (Vs-), U13.1 (GND), U13.2 (GND); no longer C5.2, RV1.3
- net STRAIN: now also R10.2, C20.1
- net SUSPENSION : now also R11.2, C21.1; no longer J1.13 (1), U7. (GND)
- net Vin+: now also U12.4 (+)
- net Vin-: now also U12.1 (-); no longer RV1.2
- net at R11.1: now also J1.13 (1), U7. (GND); no longer R10.1
- net Vrefout renamed 1V6_Vref
- net 1V6_Vref: now also RV1.2, RV1.3, C11.1, U12.6 (Ref), U13.6 (VREF); no longer R7.1
- new net: C19.1, U13.5 (NR)
- new net: R18.1, U12.2 (Rg)
- new net: R18.2, U12.3 (Rg)
- new net: R10.1, U12.7
Other:
- note added: "1.19V min"
- note added: "1.21V max"
- note added: "1.2V nom"
- note added: "100Hz cut off"
- note added: "124 ohm max resistance 116 ohm min resistance"
- note added: "160=1+(49.4k/Rg) Rg=309 E96 series"
- note added: "1x1 Tire Temp Sense"
- note added: "Brake Temp Sense +5V"
- note added: "Brake Temp Sense CANH"
- note added: "Brake Temp Sense CANL"
- note added: "Brake Temp Sense GND"
- note added: "Brake temp sensor"
- note added: "G=1+(49.4k/Rg)"
- note added: "Strain Gauge"
- note added: "Suspension Travel +3V3"
- note added: "Vout=Vref + G*(Vin+ - Vin-)"
- note added: "current draw is about 7 mA of the whole circuit here"
- note added: "equivalent resistance is 240 ohm of the whole circuit from V+ to ground"
- note removed: "Changed to Pot was previously resistor and arrow"
- note removed: "Instrumentation Amplifier"
- note removed: "Suspension Travle +3V3"
- note removed: "Tire Temp Sense +5V"
- note removed: "Tire Temp Sense CANH"
- note removed: "Tire Temp Sense CANL"
- note removed: "Tire Temp Sense GND"
- note removed: "current draw is about 42 mA of the whole circuit here"
- note removed: "equivanet resistance is 120ohm of the whole circuit from V+ to ground"
- note removed: "pins 19-22 tire temp sensor ?"
- note removed: "pins should be assigned now"
- note removed: "waiting for wesley on this so nothing i can do now"
- title: Peripheral Boards -> Peripheral Board
- moved on the sheet: C5, R15, R7, R9, RV1, U10, U11, U7

Commit message: Edited layout, very much a rough draft
Parts:
- added R19, R20: 16K, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, symbol Device:R_US
- C14: footprint Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder -> Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
- J1: footprint (none) -> FS_4_Global_Footprint_Library:ATS13-26PA-BM01
Connections:
- net CANH: now also SW5.4; no longer R4.2
- net CANL: now also R4.2; no longer SW5.3
- net Vin+: now also R20.1; no longer U12.4 (+)
- net Vin-: now also R19.1; no longer U12.1 (-)
- net at R14.2, U3.6 (PA1): now also SW5.3; no longer SW5.4
- new net: R20.2, U12.4 (+)
- new net: R19.2, U12.1 (-)
Other:
- moved on the sheet: R14, R4, SW5

Commit message: More small changes
Parts:
- added H1, H2: MountingHole_Pad, MountingHole:MountingHole_3.2mm_M3_Pad, symbol Mechanical:MountingHole_Pad
- U4: footprint Package_SO:SOIC-8_3.9x4.9mm_P1.27mm -> FS_4_Global_Footprint_Library:SOIC-8_ISO1044BD
Connections:
- net GND: now also H1.1, H2.1
Other:
- note added: "Mouting holes"
- note added: "these for vdda"

Commit message: move components significantly
Parts:
- removed Suspenison_travel1: ~, symbol FS_4_Global_Symbol_Library:suspenison_sense
- added unit 4 of J1
- R19, R20: value 16K -> 10k
Connections:
- net +3V3: now also J1.12; no longer J1.12
- net CANH: now also J1.21; no longer J1.20
- net CANL: now also J1.20; no longer J1.21
- net GND: now also J1.14; no longer J1.14
- new net: J1.13 (1), R11.1, U7. (GND)
Other:
- moved on the sheet: U7
Changed lines of the file:
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@@
 	(text "Brake Temp Sense CANH"
 		(exclude_from_sim no)
-		(at 218.44 96.52 0)
+		(at 218.44 99.06 0)
 		(effects
 			(font
@@
 	(text "Brake Temp Sense CANL"
 		(exclude_from_sim no)
-		(at 218.44 99.06 0)
+		(at 218.44 96.52 0)
 		(effects
 			(font
@@
 	(wire
 		(pts
-			(xy 285.75 99.06) (xy 312.42 99.06)
+			(xy 287.02 99.06) (xy 312.42 99.06)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 309.88 96.52) (xy 285.75 96.52)
+			(xy 309.88 96.52) (xy 287.02 96.52)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 254 81.28) (xy 236.22 81.28)
+			(xy 252.73 81.28) (xy 236.22 81.28)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 285.75 93.98) (xy 307.34 93.98)
+			(xy 287.02 93.98) (xy 307.34 93.98)
 		)
 		(stroke
@@
 	(global_label "CANL"
 		(shape input)
-		(at 252.73 83.82 0)
+		(at 252.73 81.28 0)
 		(fields_autoplaced yes)
 		(effects
@@
 		)
 		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 260.4324 83.82 0)
+			(at 260.4324 81.28 0)
 			(effects
 				(font
@@
 	(global_label "CANH"
 		(shape input)
-		(at 254 81.28 0)
+		(at 252.73 83.82 0)
 		(fields_autoplaced yes)
 		(effects
@@
 		)
 		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 262.0048 81.28 0)
+			(at 260.7348 83.82 0)
 			(effects
 				(font
@@
 		)
 		(pin "28"
-			(alternate "PB5")
 		)
 		(pin "20"
@@
 		(exclude_from_sim no)
 		(in_bom yes)
-		(on_board no)
+		(on_board yes)
 		(dnp no)
 		(property "Reference" "TP6"
@@
 		(exclude_from_sim no)
 		(in_bom yes)
-		(on_board no)
+		(on_board yes)
 		(dnp no)
 		(property "Reference" "TP1"
@@
 			)
 		)
-		(property "Value" "16K"
+		(property "Value" "10k"
 			(at 33.02 97.79 90)
 			(effects
@@
 		(exclude_from_sim no)
 		(in_bom yes)
-		(on_board no)
+		(on_board yes)
 		(dnp no)
 		(property "Reference" "TP2"
@@
 		(exclude_from_sim no)
 		(in_bom yes)
-		(on_board no)
+		(on_board yes)
 		(dnp no)
 		(property "Reference" "TP5"
@@
 		(on_board yes)
 		(dnp no)
-		(fields_autoplaced yes)
 		(property "Reference" "SW5"
 			(at 152.4 170.18 0)
@@
 	(symbol
 		(lib_id "FS_4_Global_Symbol_Library:suspension_travel")
-		(at 278.13 96.52 0)
+		(at 279.4 96.52 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(dnp yes)
 		(property "Reference" "U7"
-			(at 288.29 83.82 0)
+			(at 289.56 83.82 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "Suspension Travel Sensor"
-			(at 279.4 104.14 0)
+			(at 280.67 104.14 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" ""
-			(at 278.13 96.52 0)
+			(at 279.4 96.52 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" ""
-			(at 278.13 96.52 0)
+			(at 279.4 96.52 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" ""
-			(at 278.13 96.52 0)
+			(at 279.4 96.52 0)
 			(effects
 				(font
@@
 		)
 		(property "Name" ""
-			(at 278.13 96.52 0)
+			(at 279.4 96.52 0)
 			(effects
 				(font
@@
 		)
 		(property "Manufacturer Part Number" ""
-			(at 278.13 96.52 0)
+			(at 279.4 96.52 0)
 			(effects
 				(font
@@
 		)
 		(property "Digikey Part Number" ""
-			(at 278.13 96.52 0)
+			(at 279.4 96.52 0)
 			(effects
 				(font
@@
 		)
 		(property "Digikey Link" ""
-			(at 278.13 96.52 0)
+			(at 279.4 96.52 0)
 			(effects
 				(font
@@
 		(exclude_from_sim no)
 		(in_bom yes)
-		(on_board no)
+		(on_board yes)
 		(dnp no)
 		(property "Reference" "TP3"
@@
 			)
 		)
-		(property "Value" "16K"
+		(property "Value" "10k"
 			(at 34.29 80.01 90)
 			(effects
@@
 		(exclude_from_sim no)
 		(in_bom yes)
-		(on_board no)
+		(on_board yes)
 		(dnp no)
 		(property "Reference" "TP4"
@@
 					(unit 1)
 				)
-			)
-		)
-	)
-	(symbol
-		(lib_id "FS_4_Global_Symbol_Library:suspenison_sense")
-		(at 278.13 96.52 0)
-		(unit 1)
-		(exclude_from_sim no)
-		(in_bom yes)
-		(on_board yes)
-		(dnp no)
-		(property "Reference" "Suspenison_travel1"
-			(at 267.97 104.14 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(justify left)
-				(hide yes)
-			)
-		)
-		(property "Value" "~"
-			(at 284.48 97.79 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(justify left)
-			)
-		)
-		(property "Footprint" ""
-			(at 278.13 96.52 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Datasheet" ""
-			(at 278.13 96.52 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Description" ""
-			(at 278.13 96.52 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Name" ""
-			(at 278.13 96.52 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Manufacturer Part Number" ""
-			(at 278.13 96.52 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(instances
-			(project ""
-				(path "/3ffe4db1-2415-46df-8a68-5537f544061f"
-					(reference "Suspenison_travel1")
-					(unit 1)
-				)

Commit message: Added level shifters
Parts:
- removed R16, R17, R6, R8: 4.7k, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, symbol Device:R
- added C22, C23, C24, C25: 100nF, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, symbol Device:C
- added Suspenison_travel1: ~, symbol FS_4_Global_Symbol_Library:suspenison_sense
- added U14, U2: TCA9406DC, Package_SO:SSOP-8_2.95x2.8mm_P0.65mm, symbol Interface:TCA9406DC
- R19, R20: value 10k -> 16K
Connections:
- net +3V3: now also C22.1, C24.1, U14.3 (VCCA), U2.3 (VCCA)
- net +5V: now also C23.2, C25.2, U14.7 (VCCB), U2.7 (VCCB)
- net 1x1_TireTemp_Sensor_SCL: now also U14.8 (SCL_B); no longer J1.17, U10. (GND)
- net 1x1_TireTemp_Sensor_SDA: now also U14.1 (SDA_B); no longer J1.16, U10. (GND)
- net 1x8_TireTemp_Sensor_SCL: now also U2.8 (SCL_B); no longer J1.25, U9. (GND)
- net 1x8_TireTemp_Sensor_SDA: now also U2.1 (SDA_B); no longer J1.24, U9. (GND)
- net CANH: now also J1.20; no longer J1.21
- net CANL: now also J1.21; no longer J1.20
- net GND: now also C22.2, C23.1, C24.2, C25.1, U14.2 (GND), U2.2 (GND)
- new net: J1.24, U2.4 (SDA_A), U9. (GND)
- new net: J1.25, U2.5 (SCL_A), U9. (GND)
- new net: J1.16, U10. (GND), U14.5 (SCL_A)
- new net: J1.17, U10. (GND), U14.4 (SDA_A)
- no-connect marks 8 -> 10
Other:
- note added: "Sensor blocks"
- note removed: "Sensor block"
- moved on the sheet: C21, C6, C8, C9, D1, H1, H2, J1A, J1C, J1D, J1E, J1F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
