File: steering-wheel-board/steering_wheel.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: power, can, and bridgetek drivers on steering wheel board schematic
Parts:
- added C1: 10uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C
- added C2, C6, C7: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C
- added C3: 47uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C
- added C4, C5: 1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C
- added J1: Connector Type TBD, symbol Connector:Conn_01x06_Pin
- added L1: 4.7uF, Inductor_SMD:L_Bourns_SRP5030T, symbol Device:L
- added U1: AP63205WU, Package_TO_SOT_SMD:TSOT-23-6, symbol Regulator_Switching:AP63205WU
- added U2: MIC5504-3.3YM5, Package_TO_SOT_SMD:SOT-23-5, symbol Regulator_Linear:MIC5504-3.3YM5
- added U3: ISO1044BD, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, symbol Interface_CAN_LIN:ISO1044BD
Connections:
- new net: C2.1, L1.1, U1.5 (SW)
- new net: C2.2, U1.6 (BST)
- new net +12V: C1.2, J1.1 (Pin_1), U1.2 (EN), U1.3 (IN)
- new net +3V3: C5.2, C6.1, U2.5 (VOUT), U3.1 (VCC1)
- new net +5V: C3.2, C4.2, C7.1, L1.2, U1.1 (FB), U2.1 (VIN), U2.3 (EN), U3.8 (VCC2)
- new net CAN_H: J1.3 (Pin_3), U3.6 (CANH)
- new net CAN_L: J1.4 (Pin_4), U3.5 (CANL)
- new net CAN_RX: U3.3 (RXD)
- new net CAN_TX: U3.2 (TXD)
- new net GND: C1.1, C3.1, C4.1, C5.1, C6.2, C7.2, J1.2 (Pin_2), U1.4 (GND), U2.2 (GND), U3.4 (GND1), U3.7 (GND2)
- new net Lap Signal: J1.6 (Pin_6)
- new net Launch Control Signal: J1.5 (Pin_5)
Other:
- added sheet Bridgetek Display Driver (bridgetek.kicad_sch)
- note added: "Board Connections"
- note added: "CAN"
- note added: "Power"
- note added: "TODO Secondary Connector Internal connections for all the buttons TBD until we source specific encoders and buttons because I don't know how many pins we'll need"
- title: [BOARD NAME] -> Steering Wheel Board

Commit message: began work on MCU schematic sheet
Other:
- added sheet MCU (MCU.kicad_sch)
Changed lines of the file:
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@@
 		(dnp no)
 		(fields_autoplaced yes)
-		(property "Reference" "#FLG"
+		(property "Reference" "#FLG?"
 			(at 224.79 29.845 0)
 			(effects
@@
 				)
 			)
+			(project "steering_wheel"
+				(path "/553a23ec-442a-4f98-939d-2d5634a662f5"
+					(reference "#FLG?")
+					(unit 1)
+				)
+			)
 			(project "DCDC_5V_2A"
 				(path "/9d41e1f5-de27-446c-8a64-25407fbe48af"
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "#PWR"
+		(property "Reference" "#PWR?"
 			(at 81.28 113.03 0)
 			(effects
@@
 		)
 		(instances
+			(project "steering_wheel"
+				(path "/553a23ec-442a-4f98-939d-2d5634a662f5"
+					(reference "#PWR?")
+					(unit 1)
+				)
+			)
 			(project ""
 				(path "/be8abe95-fa0e-434f-bf97-73945cc728ef"
@@
 		(dnp no)
 		(fields_autoplaced yes)
-		(property "Reference" "#PWR"
+		(property "Reference" "#PWR?"
 			(at 232.41 35.56 0)
 			(effects
@@
 				)
 			)
+			(project "steering_wheel"
+				(path "/553a23ec-442a-4f98-939d-2d5634a662f5"
+					(reference "#PWR?")
+					(unit 1)
+				)
+			)
 			(project "DCDC_5V_2A"
 				(path "/9d41e1f5-de27-446c-8a64-25407fbe48af"
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "#PWR"
+		(property "Reference" "#PWR?"
 			(at 50.8 128.27 0)
 			(effects
@@
 		)
 		(instances
+			(project "steering_wheel"
+				(path "/553a23ec-442a-4f98-939d-2d5634a662f5"
+					(reference "#PWR?")
+					(unit 1)
+				)
+			)
 			(project ""
 				(path "/be8abe95-fa0e-434f-bf97-73945cc728ef"
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "#PWR"
+		(property "Reference" "#PWR?"
 			(at 46.99 102.87 0)
 			(effects
@@
 		)
 		(instances
+			(project "steering_wheel"
+				(path "/553a23ec-442a-4f98-939d-2d5634a662f5"
+					(reference "#PWR?")
+					(unit 1)
+				)
+			)
 			(project ""
 				(path "/be8abe95-fa0e-434f-bf97-73945cc728ef"
@@
 		(dnp no)
 		(fields_autoplaced yes)
-		(property "Reference" "#PWR"
+		(property "Reference" "#PWR?"
 			(at 273.05 53.34 0)
 			(effects
@@
 				(path "/1eaf6089-efbb-4c23-ad74-83bc24c8d4ef"
 					(reference "#PWR03")
+					(unit 1)
+				)
+			)
+			(project "steering_wheel"
+				(path "/553a23ec-442a-4f98-939d-2d5634a662f5"
+					(reference "#PWR?")
 					(unit 1)
 				)
@@
 		(dnp no)
 		(fields_autoplaced yes)
-		(property "Reference" "#PWR"
+		(property "Reference" "#PWR?"
 			(at 182.88 35.56 0)
 			(effects
@@
 				)
 			)
+			(project "steering_wheel"
+				(path "/553a23ec-442a-4f98-939d-2d5634a662f5"
+					(reference "#PWR?")
+					(unit 1)
+				)
+			)
 			(project "DCDC_5V_2A"
 				(path "/9d41e1f5-de27-446c-8a64-25407fbe48af"
@@
 		(dnp no)
 		(fields_autoplaced yes)
-		(property "Reference" "#PWR"
+		(property "Reference" "#PWR?"
 			(at 285.75 40.64 0)
 			(effects
@@
 				(path "/1eaf6089-efbb-4c23-ad74-83bc24c8d4ef"
 					(reference "#PWR02")
+					(unit 1)
+				)
+			)
+			(project "steering_wheel"
+				(path "/553a23ec-442a-4f98-939d-2d5634a662f5"
+					(reference "#PWR?")
 					(unit 1)
 				)
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "#PWR"
+		(property "Reference" "#PWR?"
 			(at 81.28 102.87 0)
 			(effects
@@
 		)
 		(instances
+			(project "steering_wheel"
+				(path "/553a23ec-442a-4f98-939d-2d5634a662f5"
+					(reference "#PWR?")
+					(unit 1)
+				)
+			)
 			(project ""
 				(path "/be8abe95-fa0e-434f-bf97-73945cc728ef"
@@
 		(dnp no)
 		(fields_autoplaced yes)
-		(property "Reference" "#PWR"
+		(property "Reference" "#PWR?"
 			(at 201.93 53.34 0)
 			(effects
@@
 				)
 			)
+			(project "steering_wheel"
+				(path "/553a23ec-442a-4f98-939d-2d5634a662f5"
+					(reference "#PWR?")
+					(unit 1)
+				)
+			)
 			(project "DCDC_5V_2A"
 				(path "/9d41e1f5-de27-446c-8a64-25407fbe48af"
@@
 		(dnp no)
 		(fields_autoplaced yes)
-		(property "Reference" "#PWR"
+		(property "Reference" "#PWR?"
 			(at 254 40.64 0)
 			(effects
@@
 				(path "/1eaf6089-efbb-4c23-ad74-83bc24c8d4ef"
 					(reference "#PWR01")
+					(unit 1)
+				)
+			)
+			(project "steering_wheel"
+				(path "/553a23ec-442a-4f98-939d-2d5634a662f5"
+					(reference "#PWR?")
 					(unit 1)
 				)
@@
 				)
 			)
+		)
+	)
+	(sheet
+		(at 130.81 100.33)
+		(size 57.15 38.1)
+		(exclude_from_sim no)
+		(in_bom yes)
+		(on_board yes)
+		(dnp no)
+		(fields_autoplaced yes)
+		(stroke
+			(width 0.1524)
+			(type solid)
+		)
+		(fill
+			(color 0 0 0 0.0000)
+		)
+		(property "Sheetname" "MCU"
+			(at 130.81 99.6184 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left bottom)
+			)
+		)
+		(property "Sheetfile" "MCU.kicad_sch"
+			(at 130.81 139.0146 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left top)
+			)
+		)
+		(instances
+			(project "steering_wheel"
+				(path "/553a23ec-442a-4f98-939d-2d5634a662f5"
+					(page "3")
+				)
+			)

Commit message: MCU page of steering wheel schematic
Other:
- sheet MCU ports: added CAN_RX, CAN_TX, Drive_Mode_Encoder[0..2], Driver_Interrupt, Driver_Power, Layout_Cycle, Regen_Encoder[0..2], SPI{MOSI,MISO,CS,CLK}, TC_Encoder[0..2]; removed none
- moved on the sheet: C6, C7, U3

Commit message: added priority encoder for rotary dials on steering wheel to library
Other:
- added sheet Encoders (Encoders.kicad_sch)
- moved on the sheet: C6, C7, U3

Commit message: backlight circuit added to datasheet
Other:
- added sheet Backlight_Driver (backlight.kicad_sch)
Changed lines of the file:
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@@
 	(title_block
 		(title "Steering Wheel Board")
-		(date "2026-01-06")
+		(date "2026-01-07")
 		(rev "1.0")
 		(company "Formula Slug")
 		(comment 1 "Nova Mondal")
-		(comment 2 "[COLLABORATOR'S NAME HERE]")
-		(comment 3 "[ET CETRA]")
+		(comment 2 "Jesse Osteen, Brian Acosta")
 		(comment 6 "Block Diagram")
 	)
@@
 	(wire
 		(pts
+			(xy 285.75 170.18) (xy 285.75 194.31)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
+			(xy 278.13 170.18) (xy 285.75 170.18)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 227.33 31.75) (xy 232.41 31.75)
 		)
@@
 	(wire
 		(pts
+			(xy 285.75 194.31) (xy 289.56 194.31)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 43.18 179.07) (xy 30.48 179.07)
 		)
@@
 				)
 			)
+		)
+	)
+	(sheet
+		(at 289.56 185.42)
+		(size 21.59 15.24)
+		(exclude_from_sim no)
+		(in_bom yes)
+		(on_board yes)
+		(dnp no)
+		(fields_autoplaced yes)
+		(stroke
+			(width 0.1524)
+			(type solid)
+		)
+		(fill
+			(color 0 0 0 0.0000)
+		)
+		(property "Sheetname" "Backlight_Driver"
+			(at 289.56 184.7084 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left bottom)
+			)
+		)
+		(property "Sheetfile" "backlight.kicad_sch"
+			(at 289.56 201.2446 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left top)
+			)
+		)
+		(pin "Backlight_PWM" input
+			(at 289.56 194.31 180)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left)
+			)
+		)
+		(pin "LED_Low" output
+			(at 311.15 198.12 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+			)
+		)
+		(pin "LED_High" output
+			(at 311.15 190.5 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+			)
+		)
+		(instances
+			(project "steering_wheel"
+				(path "/553a23ec-442a-4f98-939d-2d5634a662f5"
+					(page "5")
+				)
+			)
