# Repository formulaslug/fs-4-schematics

File README.md:

# Notes

Please complete KiCad training before beginning or working on any projects in this repository.

Only edit another person's work if you have spoke about it with them first and they have given you permission. This applies to Leads and Captains as well.

Contact Cole Lewis, Nathaniel Platt, or Wesley Rodriguez Kronmiller or Jack Nystrom for information/help relating to this repository.

## KiCad design chargingboard/chargingboard.kicad_pcb

Parts:
C1, C4, C6, C7, C13, C32, C33, C35: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R9BB104; Digi PN 311-1344-1-ND
C2, C3: 6.8pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603DRNPO9BN6R8; Digi PN 311-3874-1-ND
C12, C31: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CL10A106KO8NQNC; Digi PN 1276-CL10A106KO8NQNCCT-ND
C17, C23, C24, C34: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX5R8BB105; Digi PN 311-1445-1-ND
C22: 47uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFG PN CL21A476MQYNNNE; Digi PN 1276-1852-1-ND
D1: D; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder; MFG PN SMD110PL-TP; Digi PN SMD110PL-TPMSCT-ND
FB2: FCM_1608KF-601T03; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MFG PN FCM1608KF-601T03; Digi PN 4816-FCM1608KF-601T03CT-ND
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1: Conn_02x13_Counter_Clockwise; ATS15-26PB-BM01; MFG PN ATS15-26PB-BM01; Digi PN 889-ATS15-26PB-BM01-ND
J2: Conn_01x04; Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical; MFG PN 1053091204; Digi PN WM14967-ND
J6: TSMP_to_HV; Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical; MFG PN 1053091102; Digi PN WM16865-ND
J7: TSMP_to_Banana Jacks; Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical; MFG PN 1053091102; Digi PN WM16865-ND
J8: J1772_Negotiation; Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical; MFG PN 1053091102; Digi PN WM16865-ND
J12: everything_connector; Molex_Nano-Fit_105310-xx12_2x06_P2.50mm_Vertical; MFG PN 1053101112; Digi PN WM16883-ND
J13: FTSH-107-01-F-DV-K-P-TR; PinHeader_2x07_P1.27mm_Vertical_SMD; MFG PN FTSH-107-01-F-DV-K-P-TR; Digi PN SAM13170CT-ND
L1: 4.7uH; L_Bourns_SRP5030T; MFG PN SRP5030TA-4R7M; Digi PN SRP5030TA-4R7MCT-ND
R1: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-0710KL; Digi PN 311-10KLDCT-ND
R3: 1600; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-071K6L; Digi PN 311-1.60KHRCT-ND
R5, R6: 5k; R_Axial_DIN0922_L20.0mm_D9.0mm_P25.40mm_Horizontal; MFG PN WNE5K0FET; Digi PN WNE5K0FETCT-ND
R7: 866; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RMCF0603FT866R; Digi PN 738-RMCF0603FT866RCT-ND
R8: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-07330RL; Digi PN 311-330HRCT-ND
R9, R13: 330k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RMCF0603JT330K; Digi PN RMCF0603JT330KCT-ND
R10: 499k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN CRCW0603499KFKEA; Digi PN 541-499KHCT-ND
R11: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN ERA-3AEB121V; Digi PN P120DBCT-ND
R12: 200k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN ERA-3AEB204V; Digi PN P200KDBCT-ND
SW1: Y97KT23B5NAFP; SW_SPST_PTS647_Sx38; MFG PN Y97KT23B5NAFP; Digi PN 108-Y97KT23B5NAFPCT-ND
TP1, TP2, TP3, TP4, TP5, TP6, TP7: TestPoint; TestPoint_Pad_D1.0mm
U1: AP63205WU; TSOT-23-6; MFG PN AP63205WU-7; Digi PN AP63205WU-7DICT-ND
U2: ISO1044BD; SOIC-8_3.9x4.9mm_P1.27mm; MFG PN ISO1044BDR; Digi PN 296-ISO1044BDRCT-ND
U3: STM32G441KBTx; LQFP-32_7x7mm_P0.8mm; MFG PN STM32G441KBT6; Digi PN 497-STM32G441KBT6-ND
U7: MIC5504-3.3YM5; SOT-23-5; MFG PN MIC5504-3.3YM5-TR; Digi PN 576-4764-1-ND
Y2: ECS-240-8-37B-CKY-TR; Crystal_SMD_2016-4Pin_2.0x1.6mm; MFG PN ECS-240-8-37B-CKY-TR; Digi PN XC3063CT-ND

Connections:
+3V3: C6.1, C24.2, C31.2, C32.2, C33.2, FB2.1, J1.1, J12.9, J13.3, U2.1 (VCC1), U3.1 (VDD), U3.17 (VDD), U7.5 (VOUT); also elsewhere on the board
+3V3_A: C34.1, C35.1, FB2.2, U3.15 (VDDA)
+5V: C7.1, C22.2, C23.2, L1.2, R8.1, U1.1 (FB), U2.8 (VCC2), U7.1 (VIN), U7.3 (EN)
+12V: C12.2, J1.7, J2.2, J12.1, J12.6, U1.2 (EN), U1.3 (IN); also elsewhere on the board
/BOOT0: R1.1, U3.31 (PB8)
/CAN_H: J1.14, J2.3, J12.11, R11.1, U2.6 (CANH)
/CAN_L: J1.20, J2.4, J12.5, R11.2, U2.5 (CANL)
/CAN_RX: U2.3 (RXD), U3.21 (PA11)
/CAN_TX: U2.2 (TXD), U3.22 (PA12)
/Control Pilot: D1.2 (A), J8.2
/Control_Pilot_Cutoff: D1.1 (K), R7.1, R9.1
/Control_Pilot_Filtered: C1.1, R9.2, R10.1, U3.5 (PA0)
/OSC_IN: C2.1, U3.2 (RCC_OSC_IN), Y2.3
/OSC_OUT: C3.1, U3.3 (RCC_OSC_OUT), Y2.1
/Proximity Pilot: J8.1, R8.2, R12.1
/Proximity_Pilot_Filtered: R12.2, R13.1, U3.6 (PA1)
/SH_RESET+: J1.9, J12.10
/SPI.CLK: U3.10 (SPI1_SCK); also elsewhere on the board
/SPI.CS: U3.9 (SPI1_NSS); also elsewhere on the board
/SPI.MISO: U3.11 (SPI1_MISO); also elsewhere on the board
/SPI.MOSI: U3.12 (SPI1_MOSI); also elsewhere on the board
/Shutdown_Acc_In: J1.8, J12.12
/Shutdown_Acc_Out: J1.16, J1.17
/Shutdown_Reset: J1.15, J12.4
/driver_power: U3.30 (PB7); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.1, C6.2, C7.2, C12.1, C17.2, C22.1, C23.1, C24.1, C31.1, C32.1, C33.1, C34.2, C35.2, J1.6, J2.1, J12.2, J12.7, J12.8, J13.5, J13.7, J13.11, R1.2, R7.2, R10.2, R13.2, SW1.1, U1.4 (GND), U2.4 (GND1), U2.7 (GND2), U3.14 (VSSA), U3.16 (VSS), U3.32 (VSS), U7.2 (GND), Y2.2, Y2.4; also elsewhere on the board
NRST: C4.2, J13.12, SW1.2, U3.4 (PG10)
unnamed: J6.1, R6.2
unnamed: J6.2, R5.2
unnamed: J7.1, R5.1
unnamed: J7.2, R6.1
unnamed: J12.3, R3.1
unnamed: C13.2, U1.6 (BST)
unnamed: C13.1, L1.1, U1.5 (SW)
unnamed: TP3.1, U3.18 (PA8)
unnamed: TP2.1, U3.20 (PA10)
unnamed: TP1.1, U3.25 (PA15)
unnamed: TP7.1, U3.13 (PB0)
unnamed: TP6.1, U3.27 (PB4)
unnamed: TP5.1, U3.28 (PB5)
unnamed: TP4.1, U3.29 (PB6)
PWM: J1.26
STLINK_SWCLK: J13.6, U3.24 (SYS_JTCK-SWCLK)
STLINK_SWDIO: J13.4, U3.23 (SYS_JTMS-SWDIO)
STLINK_SWO: J13.8, U3.26 (SYS_JTDO-SWO)
VCP_UART_RX: J13.13, U3.8 (USART2_RX)
VCP_UART_TX: J13.14, U3.7 (USART2_TX)
screen_button: C17.1, R3.2, U3.19 (PA9)

Notes on the sheet:
Trace + wire must be <150mm to busbars
STM32G441KBTx MCU
Tell the acc board that the charger is connected
CAN
GNDDETECT
J1772 Negotiation
SFC
Power Block 5v
High is no fault
TSMPs
Charger Box Components
Charge_State
Power Block 3v3
IRs_Final
24MHz

Parts:
C5, C8, C9, C10, C14, C15: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R9BB104; Digi PN 311-1344-1-ND
C11: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CL10A106KO8NQNC; Digi PN 1276-CL10A106KO8NQNCCT-ND
C16, C26: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX5R8BB105; Digi PN 311-1445-1-ND
C29: 220nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB224; Digi PN 311-1803-1-ND
J9: Conn_01x40_MountingPin; CONN_F32D-1A7Y1-21040_AMP; MFG PN F32D-1A7Y1-21040; Digi PN 609-F32D-1A7Y1-21040CT-ND
L2: 22uH; CDRH5D28NP-220NC; MFG PN CDRH5D28NP-220NC; Digi PN 308-2307-1-ND
R2: 4.99; R_1210_3225Metric_Pad1.30x2.65mm_HandSolder; MFG PN RK73H2ETTD4R99F; Digi PN 2019-RK73H2ETTD4R99FCT-ND
U5: BT817Q; VQFN-64-1EP_9x9mm_P0.5mm_EP7.15x7.15mm; MFG PN BT817Q-R; Digi PN 2005-BT817Q-RCT-ND
U6: AP3019AKTR; SOT-23-6; MFG PN AP3019AKTR-G1; Digi PN AP3019AKTR-G1DICT-ND

Connections:
+1V2: C11.1, C14.1, C15.1, C26.1, U5.2 (VCC1V2), U5.25 (VOUT1V2), U5.57 (VCC1V2)
+3V3: C5.1, C8.1, C9.1, C10.1, J9.4, U5.9 (VCCIO1), U5.17 (VCCIO3), U5.24 (VCC), U5.28 (VCCIO2); also elsewhere on the board
+12V: C16.1, L2.2, U6.6 (V_{IN}); also elsewhere on the board
/SPI.CLK: U5.3 (SCK); also elsewhere on the board
/SPI.CS: U5.6 (CS_N); also elsewhere on the board
/SPI.MISO: U5.4 (MISO); also elsewhere on the board
/SPI.MOSI: U5.5 (MOSI); also elsewhere on the board
/driver_power: U5.12 (PD_N); also elsewhere on the board
/screen_architecture/Backlight_Switch: L2.1, U6.1 (SW)
/screen_architecture/LCD_Data_Enable: J9.34, U5.35 (DE)
/screen_architecture/LCD_Display_Enable: J9.31, U5.38 (DISP)
/screen_architecture/LCD_Dot_Clock: J9.30, U5.39 (PCLK)
/screen_architecture/LCD_HSync: J9.32, U5.37 (HSYNC)
/screen_architecture/LCD_VSync: J9.33, U5.36 (VSYNC)
/screen_architecture/LED_High: C29.1, J9.2, U6.5 (V_{OUT})
/screen_architecture/LED_Low: J9.1, R2.1, U6.3 (FB)
/screen_architecture/RGB_B0: J9.21, U5.47 (B0)
/screen_architecture/RGB_B1: J9.22, U5.46 (B1)
/screen_architecture/RGB_B2: J9.23, U5.45 (B2)
/screen_architecture/RGB_B3: J9.24, U5.44 (B3)
/screen_architecture/RGB_B4: J9.25, U5.43 (B4)
/screen_architecture/RGB_B5: J9.26, U5.42 (B5)
/screen_architecture/RGB_B6: J9.27, U5.41 (B6)
/screen_architecture/RGB_B7: J9.28, U5.40 (B7)
/screen_architecture/RGB_G0: J9.13, U5.56 (G0)
/screen_architecture/RGB_G1: J9.14, U5.55 (G1)
/screen_architecture/RGB_G2: J9.15, U5.54 (G2)
/screen_architecture/RGB_G3: J9.16, U5.53 (G3)
/screen_architecture/RGB_G4: J9.17, U5.52 (G4)
/screen_architecture/RGB_G5: J9.18, U5.51 (G5)
/screen_architecture/RGB_G6: J9.19, U5.50 (G6)
/screen_architecture/RGB_G7: J9.20, U5.49 (G7)
/screen_architecture/RGB_R0: J9.5, U5.1 (R0)
/screen_architecture/RGB_R1: J9.6, U5.64 (R1)
/screen_architecture/RGB_R2: J9.7, U5.63 (R2)
/screen_architecture/RGB_R3: J9.8, U5.62 (R3)
/screen_architecture/RGB_R4: J9.9, U5.61 (R4)
/screen_architecture/RGB_R5: J9.10, U5.60 (R5)
/screen_architecture/RGB_R6: J9.11, U5.59 (R6)
/screen_architecture/RGB_R7: J9.12, U5.58 (R7)
GND: C5.2, C8.2, C9.2, C10.2, C11.2, C14.2, C15.2, C16.2, C26.2, C29.2, J9.3, J9.29, J9.36, R2.2, U5.23 (GND), U5.33 (GND), U5.48 (GND), U5.65 (GND), U6.2 (GND); also elsewhere on the board
unnamed: U5.34 (BACKLIGHT), U6.4 (CTRL)

Notes on the sheet:
Pins 37-40 are resistive touch pins Unused for our application
Screen
Pin assignments given on page 5 of Crystalfontz CFAF800480H0-043Sx datasheet

Board: 2 copper layers, 55.3 x 95.6 mm, 68 parts (1 on the bottom side), 81 nets.

## KiCad design VCU/VCU.kicad_pcb

Parts:
C1: 10uF 0805; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFG PN CL21A106KAYNNNE; Digi PN 1276-2891-1-ND
C2, C4: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603JRX7R6BB105; Digi PN 311-3484-1-ND
C3: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603JRX7R9BB104; Digi PN 311-1779-1-ND
C5: 47uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFG PN CL21A476MQYNNNE; Digi PN 1276-1852-1-ND
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1: ATS13-34PB2-BM01; MFG PN ATS13-34PB2-BM01; Digi PN 889-ATS13-34PB2-BM01-ND
J2: SS-60400-023; MFG PN SS-60400-023; Digi PN 380-SS-60400-023-ND
J3: ATS13-34PA2-BM01; MFG PN ATS13-34PA2-BM01; Digi PN 889-ATS13-34PA2-BM01-ND
L1: 4.7uH; L_Bourns_SRP5030T; MFG PN SRP5030TA-4R7M; Digi PN SRP5030TA-4R7MCT-ND
U1: AP63205WU; TSOT-23-6; MFG PN AP63205WU-7; Digi PN AP63205WU-7DICT-ND
U2: MIC5504-3.3YM5; SOT-23-5; MFG PN MIC5504-3.3YM5-TR; Digi PN 576-4764-1-ND

Connections:
+3V3: C4.2, J3.25, U2.5 (VOUT); also elsewhere on the board
+5V: C2.2, C5.2, J3.10, J3.11, J3.12, J3.13, J3.27, L1.2, U1.1 (FB), U2.1 (VIN), U2.3 (EN); also elsewhere on the board
+12V: C1.2, J1.9, J1.20, J1.24, J1.25, J1.31, J1.32, J2.7, J3.14, J3.15, J3.16, J3.17, J3.34, U1.2 (EN), U1.3 (IN); also elsewhere on the board
/APPS_1_Raw: J3.1; also elsewhere on the board
/APPS_2_Raw: J3.2; also elsewhere on the board
/BMS_LED_Cathode: J3.5; also elsewhere on the board
/BPPS_1_Raw: J3.3; also elsewhere on the board
/BSPD_LED_Cathode: J3.7; also elsewhere on the board
/Brake_LED_Cathode: J1.12; also elsewhere on the board
/CAN_Powertrain_H: J1.1; also elsewhere on the board
/CAN_Powertrain_L: J1.10; also elsewhere on the board
/Current_Analog_Raw: J1.7; also elsewhere on the board
/Current_Vref_Raw: J1.8; also elsewhere on the board
/Dash_Lap: J2.4; also elsewhere on the board
/Dash_Launch: J2.3; also elsewhere on the board
/Driverless_Signal: J1.14; also elsewhere on the board
/Front_Brake_Raw: J1.16; also elsewhere on the board
/IMD_LED_Cathode: J3.6; also elsewhere on the board
/MCU/SPS_1_Raw: J3.26; also elsewhere on the board
/MCU/Solenoid_Neg: J3.33; also elsewhere on the board
/RTD_Button_Neg: J3.8; also elsewhere on the board
/RTD_Buzzer_Neg: J1.13; also elsewhere on the board
/RTD_Buzzer_Pos: J1.21; also elsewhere on the board
/RTD_LED_Cathode: J3.9; also elsewhere on the board
/Rear_Brake_Raw: J1.15; also elsewhere on the board
/Reset_Button: J1.11; also elsewhere on the board
/Status_Indicator_Strip: J3.4; also elsewhere on the board
/TSSI_GREEN_Cathode: J1.23; also elsewhere on the board
/TSSI_RED_Cathode: J1.22; also elsewhere on the board
/UART5_RX: J1.5; also elsewhere on the board
/UART5_TX: J1.6; also elsewhere on the board
/nBMS_Fault: J1.3; also elsewhere on the board
/nIMD_Fault: J1.2; also elsewhere on the board
BOTS_Shutdown: J3.30, J3.31; also elsewhere on the board
BSPD_Shutdown_Out: J1.19; also elsewhere on the board
CAN_Data_H: J1.18, J2.2; also elsewhere on the board
CAN_Data_L: J1.26, J2.1; also elsewhere on the board
E_Stop_Shutdown: J3.22, J3.23; also elsewhere on the board
GND: C1.1, C2.1, C4.1, C5.1, H1.1, H2.1, H3.1, H4.1, J1.17, J1.33, J1.34, J2.8, J2.SH (Shield), J3.18, J3.19, J3.20, J3.21, J3.28, U1.4 (GND), U2.2 (GND); also elsewhere on the board
Inertia_Shutdown: J3.24; also elsewhere on the board
unnamed: C3.1, U1.6 (BST)
unnamed: C3.2, L1.1, U1.5 (SW)
Shutdown_In: J1.4, J3.29; also elsewhere on the board

Notes on the sheet:
Brake_Front_12V
External IMU UART
APPS_2_5V
BPPS_1_5V
Front_Brake_GND
APPS_2_GND
Dash Board
Steering Wheel PCB
Steering_Wheel_Power
Status_Indicator_Strip_5V
Everything Else
Brake_Rear_12V
SPS_1_GND
Brake_Rear_GND
Power Supply
APPS_1_GND
SIS_Bin/GND
BPPS_1_GND
APPS_1_5V
SPS_1_5V
