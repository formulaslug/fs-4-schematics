# Repository formulaslug/fs-4-schematics (continued)

## KiCad design Power Electronics Board/Power Electronics Board.kicad_pcb

Parts:
C1, C2, C4: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CL10B105KA8NNNC; Digi PN 1276-1184-1-ND
C3: 0.01uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R9BB103; Digi PN 311-1085-1-ND
C5, C6, C7, C8: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB104; Digi PN 311-1341-1-ND
D1, D2, D3: CD0603-B0340R; D_0603_1608Metric; MFG PN CD0603-B0340R; Digi PN CD0603-B0340RCT-ND
D5: Rectangular Marker Light; not fitted
F1: 3555-2; 3555-2_KEY; MFG PN 3555-2; Digi PN 36-3555-2-ND
F2: Fuse_Small; MFG PN 0299040.ZXNV; Digi PN F1037-ND; not fitted
F3, F4: 1812L110/33MR; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder; MFG PN 1812L110/33MR; Digi PN F3486CT-ND
H1, H2: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
H3: MountingHole; MountingHole_3.2mm_M3
J1, J2, J6, J8, J9, J10: 74651173R; MFG PN 74651173R; Digi PN 732-74651173RCT-ND
J3, J4: 1054301102; CONN_SD-105430-001_02_MOL; MFG PN 1054301102; Digi PN WM26090CT-ND
J5: 1054311102; CONN_SD-105431-001_02_MOL; MFG PN 1054311102; Digi PN WM26073CT-ND
J7: 1054301108; Molex-Nano-Fit_2x04_SMD_Vertical; MFG PN 1054291208; Digi PN WM26116CT-ND
K2: AZ2150-1A-12DEF; AZ2150_AMZ; MFG PN AZ2150-1A-12DEF; Digi PN 3385-AZ2150-1A-12DEF-ND
K3: EW60-1A3-CL12D04,00000; EW601A3CL12D0400000; MFG PN EW60-1A3-CL12D04,00000; Digi PN PB2135-ND
K4: DS1E-ML-DC12V; MFG PN DS1E-ML-DC12V; Digi PN 255-2193-ND
Q1, Q2: AO3400A; SOT-23-3; MFG PN AO3400A; Digi PN 785-1000-1-ND
Q3: DMG2301L; SOT-23; MFG PN DMG2301L-13; Digi PN 31-DMG2301L-13CT-ND
R1: 39k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-0739KL; Digi PN 311-39.0KHRCT-ND
R2, R10, R11, R12, R15, R16, R17: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-0710KL; Digi PN 311-10.0KHRCT-ND
R4, R7: 5k; R_Axial_Power_L20.0mm_W6.4mm_P22.40mm; MFG PN UB5C-5KF1; Digi PN 696-1085-ND
R5, R6: 145k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN RT0805BRD07145KL; Digi PN 13-RT0805BRD07145KLCT-ND
R8, R18, R19: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-071KL; Digi PN 311-1KLDCT-ND
R9: 200k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RT0603BRD07200KL; Digi PN YAG1578CT-ND
R13: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-0715KL; Digi PN 311-15.0KHRCT-ND
R14: 2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-072KL; Digi PN YAG3590CT-ND
RV1: 10K; TRIM_PV36W103C01B00; MFG PN PV36W103C01B00; Digi PN 118-PV36W103C01B00-ND
TP1: RTM; TestPoint_Pad_1.0x1.0mm
TP2: 12V; TestPoint_Pad_1.0x1.0mm
TP4: Shutdown Final; TestPoint_Pad_1.0x1.0mm
TP5: 5V @TS 150V ~ 2V @TS 60V; TestPoint_Pad_1.0x1.0mm
TP6: 2.44V @ 12V ~ 2.04V @ 10V; TestPoint_Pad_1.0x1.0mm
TP7: 5V Isolated; TestPoint_Pad_1.0x1.0mm
TP8: 5V LV; TestPoint_Pad_1.0x1.0mm
TP9: +12V_BAT; TestPoint_Pad_1.0x1.0mm
TP10: TS Ready; TestPoint_Pad_1.0x1.0mm
TP11: U1A Out; TestPoint_Pad_1.0x1.0mm
TP12: U6A Out; TestPoint_Pad_1.0x1.0mm
U1, U6: MCP6004; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN MCP6004-I/SL; Digi PN MCP6004-I/SL-ND
U3: MCP1703AT-5002E/CB; TSOT-23_HandSoldering; MFG PN MCP1703AT-5002E/CB; Digi PN MCP1703AT-5002E/CBCT-ND
U4: CC1R5-1205SR-E; MFG PN CC1R5-1205SR-E; Digi PN 445-2453-ND
U5: ISOM8111DFSR; SO-4_7.6x3.6mm_P2.54mm; MFG PN ISOM8111DFSR; Digi PN 296-ISOM8111DFSRCT-ND
U7: LM555xM; SOIC-8_3.9x4.9mm_P1.27mm; MFG PN LM555CMX/NOPB; Digi PN LM555CMX/NOPBCT-ND
U8: SZNUD3124LT1G; TSOT-23_HandSoldering; MFG PN SZNUD3124LT1G; Digi PN SZNUD3124LT1GOSCT-ND

Connections:
2V Ref: R10.2, R13.1, U6.2 (-)
+5V_Isolated: C7.2, R13.2, TP7.1, U4.7 (+VOUT), U6.4 (V+)
+5V_LV: C2.1, C3.1, C8.2, R8.2, RV1.1, TP8.1, U1.4 (V+), U3.2 (VO), U5.4, U7.8 (VCC)
+12V_BAT: J1.1, J7.5, K2.2, K3.1 (NO_1), K3.2 (NO_2), K3.3 (NO_3), R1.1, TP9.1
+12V_Switched: C1.1, D5.2 (A), J7.1, J7.2, Q3.2 (S), R15.2, TP2.1, U3.3 (VI), U4.1 (+VIN)
/TS+: F4.2, R5.2
GLVMS: F1.3, F1.4, F2.2, J6.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C8.1, D1.2 (A), D2.2 (A), D3.2 (A), H1.1, H2.1, J2.1, J7.8, J9.1, J10.1, K3.A1 (S-/R-), K4.6, Q1.2 (S), Q2.2 (S), R11.1, R12.1, R16.1, R17.1, RV1.3, U1.11 (V-), U3.1 (GND), U4.2 (On/~Off), U4.3 (-VIN), U7.1 (GND), U8.2
unnamed: C5.1, R12.2, R18.1, TP11.1, U1.1
unnamed: C6.1, R14.1, TP12.1, U6.1
unnamed: D2.1 (K), K3.A3 (R+), Q3.3 (D)
unnamed: F3.2, J3.1, R7.1
unnamed: F4.1, J3.2, R4.2
unnamed: J4.1, K4.10
unnamed: J4.2, K4.7
unnamed: J5.1, R7.2
unnamed: J5.2, R4.1
unnamed: J8.1, K2.1
unnamed: K2.3, U8.3
unnamed: F1.1, F1.2, F2.1, K2.4, K3.4 (COM_1), K3.5 (COM_2), K3.6 (COM_3)
unnamed: Q1.1 (G), R19.1
unnamed: Q2.3 (D), Q3.1 (G), R15.1
unnamed: Q2.1 (G), R18.2
unnamed: R5.1, R6.2
unnamed: R14.2, U5.1
unnamed: RV1.2, U1.3 (+)
unnamed: R1.2, R11.2, TP6.1, U1.2 (-)
unnamed: R2.2, R6.1, TP5.1, U6.3 (+)
unnamed: R8.1, R9.1, U7.7 (DIS)
unnamed: R17.2, R19.2, TP1.1, U7.3 (Q)
unnamed: R16.2, U5.3, U7.4 (R)
unnamed: C4.1, R9.2, U7.2 (TR), U7.6 (THR)
RTM_In: D5.1 (K), J7.3, Q1.3 (D)
Reset_Button_In: D3.1 (K), J7.4, K3.A2 (S+)
Shutdown_Final: D1.1 (K), J7.7, K4.1, TP4.1
TS-: C6.2, C7.1, F3.1, R2.1, R10.1, U4.5 (-VOUT), U5.2, U6.11 (V-)
TS_Ready: J7.6, TP10.1, U8.1

Notes on the sheet:
Discharge-
DCDC GND
Reset Button Out
Bat GND
Unused Pins
5k From ESF
RTML Logic
150V max
High Current
TS-
RTM_OUT
RTML Flashing Logic
Output Connector
12V After Fuse Box
TS Ready
GLV Fuse (ev 6.6.1) MAXI Blade 40A Fuse
12V Isolation
150(10/145+145+10) = 5V 60(10/145+145+10) = 2V
5V Linear Regulator
series to increase voltage rating
Offboard to Discharge Resistors
DOCUMENTATION
Discharge+
Bat 12V
LV Battery DCDC Logic
0V - 5V
TSMP-
Discharge Relay
TS+
2V Ref
astable 3.6hz 139ms high & low
DCDC 12V
5V Isolation
TSMP+
5(10k/(10k+15k)) = 2V

Board: 2 copper layers, 145.3 x 72.6 mm, 70 parts (0 on the bottom side), 37 nets.

## KiCad design Tractive_Battery_Board/Tractive_Battery_Board.kicad_pcb

Parts:
C1, C2: 6.8pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603CRNPO9BN6R8; Digi PN 311-3861-1-ND
C3, C6, C7, C8, C9, C10, C11, C13, C14, C15, C16, C17, C18, C19, C20, C25, C26: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB104; Digi PN 311-1341-1-ND
C4: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFG PN CL21A475KAQNNNE; Digi PN 1276-1244-1-ND
C5, C23: 10uF; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN CL21A106KAYNNNE; Digi PN 1276-2891-1-ND
C12, C22, C24: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB105; Digi PN 311-1802-1-ND
C21: 15nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB153; Digi PN 311-4080-1-ND
C27: 47uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFG PN CL21A476MQYNNNE; Digi PN 1276-1852-1-ND
D1, D2, D3, D4, D5, D6: PLZ3V3B-G3/H; D_SMF; MFG PN PLZ3V3B-G3/H; Digi PN PLZ3V3B-G3/HGIDKR-ND
FB1: FCM 1608KF-601T03; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MFG PN FCM 1608KF-601T03; Digi PN 4816-FCM1608KF-601T03CT-ND
H1, H2: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1: FTSH-107-01-F-DV-K-P-TR; PinHeader_2x07_P1.27mm_Vertical_SMD; MFG PN FTSH-107-01-F-DV-K-P-TR; Digi PN SAM13170CT-ND
J2: IMD_Connector; 1054311103 - 3-Pin Molex Nano-fit; MFG PN 1054311103; Digi PN WM26074CT-ND
J3: Busbar_Temp_Sense; 1054311202 - 2-Pin Molex Nano-fit; MFG PN 1054311102; Digi PN WM26073CT-ND
J4: Cooling_TS; 1054311202 - 2-Pin Molex Nano-fit; MFG PN 1054311102; Digi PN WM26073CT-ND
J5: E-Meter; 1054311202 - 2-Pin Molex Nano-fit; MFG PN 1054311102; Digi PN WM26073CT-ND
J6: BMS_TS; 1054311202 - 2-Pin Molex Nano-fit; MFG PN 1054311102; Digi PN WM26073CT-ND
J7: Conn_02x13_Counter_Clockwise; ATS15-26PA-BM01; MFG PN ATS15-26PA-BM01; Digi PN 889-ATS15-26PA-BM01-ND
JP1: Jumper_2_Open; PinHeader_2x01_P2.54mm_Vertical; MFG PN M20-9990246; Digi PN 952-2262-ND
L1: 4.7uH; L_Bourns_SRP5030T; MFG PN SRP5030T-4R7M; Digi PN SRP5030T-4R7MCT-ND
Q1: AO3400A; SOT-23; MFG PN AO3400A; Digi PN 785-1000-1-ND
Q2: AO3401A; SOT-23; MFG PN AO3401A; Digi PN 785-1001-1-ND
R1, R2, R24, R25, R28: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-0710KL; Digi PN 311-10KLDCT-ND
R3, R4: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-07120RL; Digi PN 311-120HRCT-ND
R5, R7, R10, R12: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-0720KL; Digi PN 311-20.0KHRCT-ND
R6, R8, R11, R13: 6.8k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-076K8L; Digi PN YAG3627CT-ND
R9, R22, R23: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-13100KL; Digi PN 13-AC0603FR-13100KLCT-ND
R14, R15, R16, R17, R18, R29: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-0715KL; Digi PN 311-15.0KHRCT-ND
R19: 1.3k; R_2010_5025Metric_Pad1.40x2.65mm_HandSolder; MFG PN AC2010FK-071K3L; Digi PN YAG4005CT-ND
R20: 330; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; MFG PN RC1206JR-07330RL; Digi PN 311-330ERCT-ND
R21: 560; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; MFG PN RC1206FR-07560RL; Digi PN 311-560FRCT-ND
R26: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-074K7L; Digi PN YAG3613CT-ND
R27: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-075K1L; Digi PN 311-5.10KHRCT-ND
SW1: Y97KT23B5NAFP; SW_SPST_PTS647_Sx38; MFG PN Y97KT23B5NAFP; Digi PN 108-Y97KT23B5NAFPCT-ND
SW2: SW_Push; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
TP1: MISO_TP; TestPoint_Pad_D1.0mm
TP2: MOSI_TP; TestPoint_Pad_D1.0mm
TP3: SCK_TP; TestPoint_Pad_D1.0mm
TP4: CK_TP; TestPoint_Pad_D1.0mm
TP16: PC13_TP; TestPoint_Pad_D1.0mm
TP17: PC14_TP; TestPoint_Pad_D1.0mm
TP18: PC15_TP; TestPoint_Pad_D1.0mm
TP19: PC7_TP; TestPoint_Pad_D1.0mm
TP20: PC8_TP; TestPoint_Pad_D1.0mm
U1: STLINK-V3MODS; MODULE_STLINK-V3MODS; PARTREV 1; Digi PN 497-STLINK-V3MODS-ND
U2: STM32F446RETx; LQFP-64_10x10mm_P0.5mm; MFG PN STM32F446RET6; Digi PN 497-15376-ND
U3, U4: ISO1044BD; SOIC-8_ISO1044BD; MFG PN ISO1044BD; Digi PN 296-ISO1044BD-ND
U5: DS18B20Z+; SOIC-8_3.9x4.9mm_P1.27mm; MFG PN DS18B20Z+; Digi PN DS18B20Z+-ND
U6: MIC5504-3.3YM5; SOT-23-5; MFG PN MIC5504-3.3YM5-TR; Digi PN 576-4764-1-ND
U7: AP63205WU; TSOT-23-6; MFG PN AP63205WU-7; Digi PN AP63205WU-7DICT-ND
Y1: ECS-240-8-37B-CKY-TR; Crystal_SMD_2016-4Pin_2.0x1.6mm; MFG PN ECS-240-8-37B-CKY-TR; Digi PN XC3063CT-ND

Connections:
+3V3: C5.2, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C24.2, FB1.1, J1.3, Q2.3 (D), R26.1, U1.30 (T_VCC), U2.1 (VBAT), U2.19 (VDD), U2.32 (VDD), U2.48 (VDD), U2.64 (VDD), U3.1 (VCC1), U4.1 (VCC1), U6.5 (VOUT); also elsewhere on the board
+3V3_A: C12.1, C13.1, FB1.2, U2.13 (VDDA)
+5V: C14.1, C15.1, C22.2, C27.2, J7.26, L1.2, R25.1, U1.22 (5V_OPT), U3.8 (VCC2), U4.8 (VCC2), U6.1 (VIN), U6.3 (EN), U7.1 (FB); also elsewhere on the board
+12V: C23.2, J2.2, J7.1, R5.2, U7.2 (EN), U7.3 (IN); also elsewhere on the board
/BOOT0: R1.1, U2.60 (BOOT0)
/BOOT1: R2.1, U2.28 (PB2)
/IMD_FAULT_12V: J2.1, R19.1
/OSC_IN: C1.1, U2.5 (RCC_OSC_IN), Y1.3
/OSC_OUT: C2.1, U2.6 (RCC_OSC_OUT), Y1.1
/Shutdown + IMD Delay/BMS_FAULT_5V: Q1.3 (D), R25.2; also elsewhere on the board
/nIMD_FAULT_5V: R19.2, R20.1; also elsewhere on the board
CAN_2_RD: U2.33 (PB12), U3.3 (RXD)
CAN_2_TD: U2.34 (CAN2_TX), U3.2 (TXD)
CAN_H_1: J7.3, J7.5, U4.6 (CANH)
CAN_H_2: J7.14, J7.17, U3.6 (CANH)
CAN_L_1: J7.4, R4.2, U4.5 (CANL)
CAN_L_2: J7.15, R3.2, U3.5 (CANL)
CAN_L_RES_1: J7.6, R4.1
CAN_L_RES_2: J7.16, R3.1
CAN_POWERTRAIN_RD: U2.44 (CAN1_RX), U4.3 (RXD)
CAN_POWERTRAIN_TD: U2.45 (CAN1_TX), U4.2 (TXD)
Charge_State: J7.24, R9.1, R14.1
Charge_State_Filtered: C16.1, D3.1 (K), R14.2, U2.10 (ADC1_IN12)
Fan_PWM: J7.7, U2.39 (TIM3_CH3)
GLV_Voltage: C17.1, D1.1 (K), R15.2, U2.23 (ADC2_IN7)
GND: C1.2, C2.2, C3.1, C4.1, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.1, C23.1, C24.1, C26.2, C27.1, D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), H1.1, H2.1, J1.5, J1.7, J1.11, J2.3, J3.2, J4.2, J5.2, J6.2, J7.2, Q1.2 (S), R1.2, R2.2, R6.1, R8.1, R9.2, R11.1, R13.1, R21.2, R23.1, R28.1, SW1.1, U1.5 (GNDDETECT), U1.8 (GND_2), U1.24 (GND), U1.26 (GND2), U1.27 (GND3), U1.29 (GND4), U2.12 (VSSA), U2.18 (VSS), U2.31 (VSS), U2.47 (VSS), U2.63 (VSS), U3.4 (GND1), U3.7 (GND2), U4.4 (GND1), U4.7 (GND2), U5.3 (V_{DD}), U5.5 (GND), U6.2 (GND), U7.4 (GND), Y1.2, Y1.4; also elsewhere on the board
IMD_Fault_3V3: C21.1, D6.1 (K), R22.2, U2.24 (ADC1_IN14)
IRs_Final: J7.20, R7.2; also elsewhere on the board
NRST: C3.2, J1.12, SW1.2, U1.31 (T_NRST), U2.7 (NRST)
unnamed: J4.1, J5.1, J6.1, JP1.1 (A)
unnamed: Q1.1 (G), R24.1
unnamed: R10.1, R11.2, R17.1
unnamed: R12.1, R13.2, R18.1
unnamed: R5.1, R6.2, R15.1
unnamed: R7.1, R8.2, R16.1
unnamed: R20.2, R21.1, R22.1
unnamed: R27.2, R28.2, R29.1
unnamed: TP20.1, U2.37 (PC6)
unnamed: TP19.1, U2.38 (PC7)
unnamed: TP16.1, U2.2 (PC13)
unnamed: TP17.1, U2.3 (PC14)
unnamed: TP18.1, U2.4 (PC15)
unnamed: C4.2, U2.30 (VCAP_1)
unnamed: C25.2, U7.6 (BST)
unnamed: C25.1, L1.1, U7.5 (SW)
SH_RESET-: J7.25, R27.1, SW2.2; also elsewhere on the board
SH_RESET_3V3: C26.1, R29.2, U2.16 (ADC2_IN2)
SPI_BMS_CS: TP4.1, U2.20 (SPI1_NSS); also elsewhere on the board
SPI_MISO: TP1.1, U2.56 (SPI1_MISO); also elsewhere on the board
SPI_MOSI: TP2.1, U2.57 (SPI1_MOSI); also elsewhere on the board
SPI_SCK: TP3.1, U2.21 (SPI1_SCK); also elsewhere on the board
STLINK_SWCLK: J1.6, U1.13 (T_JCLK/T_SWCLK), U2.49 (SYS_JTCK-SWCLK)
STLINK_SWDIO: J1.4, U1.4 (T_JTMS/T_SWDIO), U2.46 (SYS_JTMS-SWDIO)
STLINK_SWO: J1.8, U1.6 (T_JTDO/T_SWO), U2.55 (SYS_JTDO-SWO)
Shutdown_In: J7.23, R10.2; also elsewhere on the board
Shutdown_In_3V3_Filtered: C19.1, D4.1 (K), R17.2, U2.14 (ADC2_IN0)
Shutdown_Measure: C18.1, D2.1 (K), R16.2, U2.22 (ADC2_IN6)
Shutdown_Out: J7.22, R12.2; also elsewhere on the board
Shutdown_Out_3V3_Filtered: C20.1, D5.1 (K), R18.2, U2.15 (ADC2_IN1)
TS1W: J3.1, JP1.2 (B), Q2.2 (S), R26.2, U2.35 (PB14), U5.4 (DQ)
TS1W_PU_Control: Q2.1 (G), U2.36 (PB15)
TS_READY: J7.19, U2.40 (PC9)
VCP_UART_RX: J1.13, U1.15 (T_VCP_RX), U2.43 (USART1_RX)
VCP_UART_TX: J1.14, U1.12 (T_VCP_TX), U2.42 (USART1_TX)
V_Curr_Out: J7.8; also elsewhere on the board
V_Curr_Ref: J7.9; also elsewhere on the board
V_Out_Negative: J7.10, U2.9 (ADC1_IN11); also elsewhere on the board
V_Out_Positive: J7.11, U2.8 (ADC1_IN10); also elsewhere on the board
nBMS_FAULT_VCU: J7.12; also elsewhere on the board
nBMS_Fault_3V3: R23.2, R24.2, U2.25 (ADC1_IN15)
nIMD_FAULT_VCU: J7.13; also elsewhere on the board
nPreCharge_Control: U2.26 (ADC2_IN8); also elsewhere on the board

Notes on the sheet:
~100Hz RC Filter
SH_Reset
Power Block
ST-Link Programming/Debugging Connector
Decoupling 100nF capacitors need to be placed as close to respective Vdd/Vss as possible. Note that VSS contains all VSS mcu pins for each VDD/VSS pair.
STLINKV3-MODS Programmer
MCU Protections
STM32F446RETx MCU
NOTE: CAN Bridge left disconnected for now, but if we can figure out the protocol on the usb side to access it, we can connect it
HV Voltage Indicator
CAN Transciever
E-Meters
24MHz
Precharge Circuit
IsoSPI
SH_RESET+
TB Board Mount E-Meter
include diagraam for IRs
Current Sensor + Filtering
source digikey part
Shutdown + IMD Delay
Auxillary Connectors

Parts:
C41: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB104; Digi PN 311-1341-1-ND
J13: TS; 1054311202 - 2-Pin Molex Nano-fit; MFG PN 1054311102; Digi PN WM26073CT-ND
J14: HVIL+/HVIL-; 1054311202 - 2-Pin Molex Nano-fit; MFG PN 1054311102; Digi PN WM26073CT-ND
PS1: TMR_3-7211WIR; TMR 3-7211WIR; MFG PN TMR 3-7211WIR; Digi PN 1951-2005-ND
R50: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-0715KL; Digi PN 311-15.0KHRCT-ND
R51, R54: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-0710KL; Digi PN 311-10KLDCT-ND
R52, R53: 145k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN RT0805BRD07145KL; Digi PN 13-RT0805BRD07145KLCT-ND
U17: MCP6004; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN MCP6004T-I/SL; Digi PN MCP6004T-I/SLCT-ND

Connections:
/HVIL/HVIL_P: J14.1, U17.1
/HVIL/TS_P: J13.2, PS1.2 (+VIN(VCC)), R52.1
unnamed: C41.2, PS1.6 (+VOUT), R50.1, U17.4 (V+)
unnamed: R52.2, R53.1
unnamed: R53.2, R54.2, U17.3 (+)
unnamed: R50.2, R51.1, U17.2 (-)
TS_N: C41.1, J13.1, J14.2, PS1.1 (-VIN(GND)), PS1.7 (-VOUT), R51.2, R54.1, U17.11 (V-)

Notes on the sheet:
(TS+)*(1/30)

Parts:
C28, C29: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB104; Digi PN 311-1341-1-ND
C30: 15pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603JRNPO9BN150; Digi PN 311-1060-1-ND
C31: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KPX7R8BB103; Digi PN 13-CC0603KPX7R8BB103CT-ND
J8: IsoSPI; 1054311202 - 2-Pin Molex Nano-fit; MFG PN 1054311102; Digi PN WM26073CT-ND
L2: HM2113ZNL; HM2113ZNLT; MFG PN HM2113ZNLT; Digi PN 553-HM2113ZNLTCT-ND
R30: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-072K2L; Digi PN 311-2.20KHRCT-ND
R31: 1.5K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-071K5L; Digi PN 311-1.50KHRCT-ND
R32: 680; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-07680RL; Digi PN 311-680HRCT-ND
R33: 402; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07402RL; Digi PN 13-AC0603FR-07402RLCT-ND
R34: 220; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-07220RL; Digi PN 311-220HRCT-ND
R35, R36: 22; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-0722RL; Digi PN 311-22.0HRCT-ND
TP5: IsoSPI_P; TestPoint_Pad_D1.0mm
TP6: IsoSPI_N; TestPoint_Pad_D1.0mm
U8: LTC6820; MSOP-16_3x4.039mm_P0.5mm; MFG PN LTC6820HMS#3ZZTRPBF; Digi PN 505-LTC6820HMS#3ZZTRPBFCT-ND

Connections:
+3V3: C28.1, C29.1, R30.2, U8.1 (EN), U8.6 (V_DDS), U8.9 (V_DD), U8.12 (MSTR); also elsewhere on the board
/IsoSPI/IBIAS: R31.1, U8.16 (IBIAS)
/IsoSPI/ICMP: R31.2, R32.1, U8.15 (ICMP)
/IsoSPI/IsoSPI+: L2.4, R33.1, U8.11 (IP)
/IsoSPI/IsoSPI-: C30.2, L2.6, U8.10 (IM)
GND: C28.2, C29.2, C31.2, R32.2, U8.7 (POL), U8.8 (PHA), U8.13 (SLOW), U8.14 (GND); also elsewhere on the board
unnamed: C30.1, R33.2
unnamed: C31.1, L2.5
unnamed: J8.1, R36.2, TP6.1
unnamed: J8.2, R35.2, TP5.1
unnamed: L2.1, R34.2, R36.1
unnamed: L2.3, R34.1, R35.1
SPI_BMS_CS: U8.5 (CS); also elsewhere on the board
SPI_MISO: R30.1, U8.3 (MISO); also elsewhere on the board
SPI_MOSI: U8.2 (MOSI); also elsewhere on the board
SPI_SCK: U8.4 (SCK); also elsewhere on the board

Notes on the sheet:
IsoSPI Filtering and Isolation
RB2
SPI -> IsoSPI Conversion
RB1
