# Repository formulaslug/fs-4-schematics (continued)

## KiCad design VCU/VCU.kicad_pcb (continued)

Parts:
C50, C51, C52, C53, C54: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603JRX7R9BB104; Digi PN 311-1779-1-ND
C55, C56: 12pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603FRNPO9BN120; Digi PN 311-3885-1-ND
R89: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-074K7L; Digi PN YAG3613CT-ND
U28: BME688; BME_688_Bosch_LGA-8_3x3mm_P0.8mm_ClockwisePinNumbering; PARTREV 1.0; Digi PN 828-BME688CT-ND
U29: BNO086; BNO086_LGA-28_5.2x3.8mm_P0.5mm; MFG PN BNO086; Digi PN 1888-BNO086CT-ND
XTAL1: ABS07-120-32.768KHZ-T; Crystal_SMD_EuroQuartz_EQ161-2Pin_3.2x1.5mm_HandSoldering; MFG PN ABS07-32.768KHZ-T; Digi PN 535-9542-1-ND

Connections:
+3V3: C50.1, C51.1, C53.2, C54.2, R89.1, U28.6 (VDDIO), U28.8 (VDD), U29.3 (VDD), U29.5 (PS1), U29.28 (VDDIO); also elsewhere on the board
BME_NSS: U28.2 (CSB); also elsewhere on the board
BNO_BOOTN: R89.2, U29.4 (BOOTN); also elsewhere on the board
BNO_NRST: U29.11 (NRST); also elsewhere on the board
GND: C50.2, C51.2, C52.1, C53.1, C54.1, C55.1, C56.1, U28.1 (GND), U28.7 (GND), U29.2 (GND), U29.10 (CLKSEL0), U29.25 (GND); also elsewhere on the board
INT1_3V3: U29.14 (H_INTN); also elsewhere on the board
unnamed: C52.2, U29.9 (CAP)
unnamed: C55.2, U29.27 (XIN32), XTAL1.1
unnamed: C56.2, U29.26 (XOUT32/CLKSEL1), XTAL1.2
SPI2_MISO: U28.5 (SDO), U29.20 (H_SDA/H_MISO/TX); also elsewhere on the board
SPI2_MOSI: U28.3 (SDI), U29.17 (SA0/H_MOSI); also elsewhere on the board
SPI2_NSS: U29.18 (H_CSN); also elsewhere on the board
SPI2_SCK: U28.4 (SCK), U29.19 (H_SCL/SCK/RX); also elsewhere on the board
WKUP1: U29.6 (PS0/WAKE); also elsewhere on the board

Notes on the sheet:
32.768 KHZ Crystal Oscillator ±20 ppm - Rated from datasheet
IMU

Board: 4 copper layers, 92.5 x 101.6 mm, 221 parts (6 on the bottom side), 179 nets.

## KiCad design BMS/BMS/BMS.kicad_pcb

Parts:
C1, C8: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFG PN AC0805KRX7R9BB103; Digi PN 311-3174-1-ND
C2, C6: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFG PN CC0805KKX7R0BB104; Digi PN 311-2083-1-ND
C3, C4, C5: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFG PN CC0805KFX7R9BB105; Digi PN 13-CC0805KFX7R9BB105CT-ND
C7: 15pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFG PN CC0805KRNPO9BN150; Digi PN 13-CC0805KRNPO9BN150CT-ND
D1, D2: LS R976-NR-1-0-20-R18; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; MFG PN LS R976-NR-1-0-20-R18; Digi PN 475-LSR976-NR-1CT-ND
J1, J2: 84952-5; 849525; MFG PN 84952-5; Digi PN A101386CT-ND
J3, J5: 512810598; MFG PN 0512810598; Digi PN 900-0512810598CT-ND
J4, J6, J7, J8: 1053131202; Nano-Fit_1054301102; MFG PN 1054301202; Digi PN WM26097CT-ND
L1: HM2113ZNLT; MFG PN HM2113ZNLT; Digi PN 553-HM2113ZNLTCT-ND
Q1: NSV1C201MZ4; SOT-223; MFG PN NSS1C201MZ4T1G; Digi PN NSS1C201MZ4T1GOSCT-ND
R1, R4: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN RC0805FR-07100RL; Digi PN 311-100CRCT-ND
R2: 10; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN RC0805FR-1010RL; Digi PN 13-RC0805FR-1010RLCT-ND
R3, R5: 160; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN RC0805FR-07160RL; Digi PN 311-160CRCT-ND
R6: 1.5k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN AC0805FR-071K5L; Digi PN YAG3701CT-ND
R7: 680; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN RC0805FR-07680RL; Digi PN 311-680CRCT-ND
R8: 402; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN AC0805FR-07402RL; Digi PN 13-AC0805FR-07402RLCT-ND
R9, R12, R14: 2.2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN RC0805JR-072K2L; Digi PN 311-2.2KARCT-ND
R10, R11, R13: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN RC0805FR-0710KL; Digi PN 311-10.0KCRCT-ND
R15, R16: 22; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN AC0805FR-0722RL; Digi PN YAG3713CT-ND
R17: 200; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN RC0805FR-07200RL; Digi PN 311-200CRCT-ND
R43: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-071KL; Digi PN 311-1KLDCT-ND
SW1: SW_DIP_x04; SW_A6H-4101_OMR; MFG PN A6H-4101; Digi PN 39-A6H-4101-ND
TP1: S6; TestPoint_Pad_D1.5mm
U1: LTC6810IG-2-TRPBF; TSSOP-44_4.4x11mm_P0.5mm; MFG PN LTC6810IG-2#3ZZPBF; Digi PN 505-LTC6810IG-2#3ZZPBF-ND

Connections:
/BB0/B#: J2.4, R1.2; also elsewhere on the board
/BB0/B#+1: J2.3; also elsewhere on the board
/BB1/B#+1: J2.2; also elsewhere on the board
/BB2/B#+1: J2.1; also elsewhere on the board
/BB3/B#+1: J1.5; also elsewhere on the board
/BB4/B#+1: J1.4; also elsewhere on the board
/BB5/B#+1: J1.3, R43.1; also elsewhere on the board
/C0: C1.1, R1.1, U1.16 (C0); also elsewhere on the board
/C1: U1.14 (C1); also elsewhere on the board
/C2: U1.12 (C2); also elsewhere on the board
/C3: U1.10 (C3); also elsewhere on the board
/C4: U1.8 (C4); also elsewhere on the board
/C5: U1.6 (C5); also elsewhere on the board
/C6: U1.4 (C6); also elsewhere on the board
/DRV: Q1.1 (B), U1.33 (DRIVE)
/S0: U1.17 (S0); also elsewhere on the board
/S1: U1.15 (S1); also elsewhere on the board
/S2: U1.13 (S2); also elsewhere on the board
/S3: U1.11 (S3); also elsewhere on the board
/S4: U1.9 (S4); also elsewhere on the board
/S5: U1.7 (S5); also elsewhere on the board
/S6: R43.2, TP1.1, U1.5 (S6)
/extIsoSPI_N: J7.1, J8.2, R16.1
/extIsoSPI_P: J7.2, J8.1, R15.1
A0: R13.1, SW1.4, U1.34 (A0)
A1: R11.1, SW1.3, U1.35 (A1)
A2: R10.1, SW1.2, U1.38 (A2)
ALERT: J3.4, R12.2, U1.19 (GPIO2)
DQ: J4.2, J5.5, J6.1
I2C_SCL: J3.2, R9.2, U1.25 (GPIO4)
I2C_SDA: J3.3, R14.2, U1.20 (GPIO3)
IBIAS: R6.2, U1.40 (SDO(IBIAS))
ICMP: R6.1, R7.2, U1.41 (SDI(ICMP))
IsoSPI_N: C7.1, L1.6, R17.1, U1.36 (CSB(IMA))
IsoSPI_P: L1.4, R8.1, SW1.1, U1.37 (SCK(IPA))
unnamed: C6.1, Q1.2 (C), Q1.4 (C), R4.1
unnamed: C7.2, R8.2
unnamed: C8.1, L1.5
unnamed: D1.2 (A), R3.1
unnamed: D1.1 (K), U1.18 (GPIO1)
unnamed: D2.2 (A), R5.1
unnamed: J1.2, R2.2, R4.2
unnamed: J4.1, J5.1, J6.2
unnamed: L1.1, R16.2
unnamed: L1.3, R15.2
unnamed: R17.2, SW1.8
unnamed: C2.2, R2.1, U1.3 (V+)
unnamed: C5.2, U1.31 (VREF1)
unnamed: C3.2, U1.30 (VREF2)
V-: C1.2, C2.1, C3.1, C4.2, C5.1, C6.2, C8.2, D2.1 (K), J2.5, J3.1, R7.1, R10.2, R11.2, R13.2, U1.1 (V-), U1.21 (V-), U1.22 (V-), U1.23 (V-), U1.24 (V-), U1.26 (DTEN), U1.28 (V-), U1.29 (V-), U1.39 (A3), U1.43 (V-), U1.44 (V-)
VREG: C4.1, J3.5, Q1.3 (E), R3.2, R5.2, R9.1, R12.1, R14.1, SW1.5, SW1.6, SW1.7, U1.27 (ISOMD), U1.32 (VREG)

Notes on the sheet:
ISOSpi Bias setting
Bottom filtering not caught by BalanceSenseBlock
This module was designed as specified in the LTC6811 datasheet.
BMS Temp Sense
E-meter temp sensor low voltage
1: ISOSpi Termintion 2: Address bit 2 3: Address bit 1 4: Address bit 0
Configuration-specific settings switches
Temp Sense Pull-Ups
ISOSpi isolation and filtering

Parts:
C9: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFG PN AC0805KRX7R9BB103; Digi PN 311-3174-1-ND
D3: LS R976-NR-1-0-20-R18; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; MFG PN LS R976-NR-1-0-20-R18; Digi PN 475-LSR976-NR-1CT-ND
D4: 9.1V; D_SOD-523; MFG PN DDZ9696T-7; Digi PN 31-DDZ9696T-7CT-ND
Q2: AO3400A; SOT-23-3; MFG PN AO3400A; Digi PN 785-1000-1-ND
R18: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN RC0805FR-07120RL; Digi PN 311-120CRCT-ND
R19: 33; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder; MFG PN RC2512FK-0733RL; Digi PN 13-RC2512FK-0733RLCT-ND
R20: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-071KL; Digi PN 311-1KLDCT-ND
R21: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN RC0805FR-07100RL; Digi PN 311-100CRCT-ND

Connections:
/BB2/B#+1: D4.2 (A), Q2.2 (S), R20.1; also elsewhere on the board
/BB3/B#+1: R18.1, R19.2, R21.2; also elsewhere on the board
/C3: C9.2; also elsewhere on the board
/C4: C9.1, R21.1; also elsewhere on the board
/S3: D4.1 (K), Q2.1 (G), R20.2; also elsewhere on the board
unnamed: D3.2 (A), R18.2
unnamed: D3.1 (K), Q2.3 (D), R19.1

Parts of its further copies:
C10, C11, C12, C13, C14: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFG PN AC0805KRX7R9BB103; Digi PN 311-3174-1-ND
D6, D8, D10, D12, D14: 9.1V; D_SOD-523; MFG PN DDZ9696T-7; Digi PN 31-DDZ9696T-7CT-ND
Q3, Q4, Q5, Q6, Q7: AO3400A; SOT-23-3; MFG PN AO3400A; Digi PN 785-1000-1-ND
R22, R26, R30, R34, R38: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN RC0805FR-07120RL; Digi PN 311-120CRCT-ND
R23, R27, R31, R35, R39: 33; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder; MFG PN RC2512FK-0733RL; Digi PN 13-RC2512FK-0733RLCT-ND
R24, R28, R32, R36, R40: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-071KL; Digi PN 311-1KLDCT-ND
R25, R29, R33, R37, R41: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN RC0805FR-07100RL; Digi PN 311-100CRCT-ND

Connections of its further copies:
/BB0/B#: D14.2 (A), Q7.2 (S), R40.1; also elsewhere on the board
/BB0/B#+1: D12.2 (A), Q6.2 (S), R36.1, R38.1, R39.2, R41.2; also elsewhere on the board
/BB1/B#+1: D10.2 (A), Q5.2 (S), R32.1, R34.1, R35.2, R37.2; also elsewhere on the board
/BB2/B#+1: R30.1, R31.2, R33.2; also elsewhere on the board
/BB3/B#+1: D6.2 (A), Q3.2 (S), R24.1; also elsewhere on the board
/BB4/B#+1: D8.2 (A), Q4.2 (S), R22.1, R23.2, R25.2, R28.1; also elsewhere on the board
/BB5/B#+1: R26.1, R27.2, R29.2; also elsewhere on the board
/C0: C14.2; also elsewhere on the board
/C1: C13.2, C14.1, R41.1; also elsewhere on the board
/C2: C12.2, C13.1, R37.1; also elsewhere on the board
/C3: C12.1, R33.1; also elsewhere on the board
/C4: C10.2; also elsewhere on the board
/C5: C10.1, C11.2, R25.1; also elsewhere on the board
/C6: C11.1, R29.1; also elsewhere on the board
/S0: D14.1 (K), Q7.1 (G), R40.2; also elsewhere on the board
/S1: D12.1 (K), Q6.1 (G), R36.2; also elsewhere on the board
/S2: D10.1 (K), Q5.1 (G), R32.2; also elsewhere on the board
/S4: D6.1 (K), Q3.1 (G), R24.2; also elsewhere on the board
/S5: D8.1 (K), Q4.1 (G), R28.2; also elsewhere on the board
unnamed 43: R22.2; also elsewhere on the board
unnamed 44: Q3.3 (D), R23.1; also elsewhere on the board
unnamed 45: R26.2; also elsewhere on the board
unnamed 46: Q4.3 (D), R27.1; also elsewhere on the board
unnamed 47: R30.2; also elsewhere on the board
unnamed 48: Q5.3 (D), R31.1; also elsewhere on the board
unnamed 49: R34.2; also elsewhere on the board
unnamed 50: Q6.3 (D), R35.1; also elsewhere on the board
unnamed 51: R38.2; also elsewhere on the board
unnamed 52: Q7.3 (D), R39.1; also elsewhere on the board

Notes on the sheet:
Balance Block

Board: 2 copper layers, 183.2 x 49.9 mm, 89 parts (0 on the bottom side), 63 nets.

Other parts of the board:
D5, D7, D9, D11, D13: LH R974-LP-1; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Their connections:
unnamed 43: D5.2 (A); also elsewhere on the board
unnamed 44: D5.1 (K); also elsewhere on the board
unnamed 45: D7.2 (A); also elsewhere on the board
unnamed 46: D7.1 (K); also elsewhere on the board
unnamed 47: D9.2 (A); also elsewhere on the board
unnamed 48: D9.1 (K); also elsewhere on the board
unnamed 49: D11.2 (A); also elsewhere on the board
unnamed 50: D11.1 (K); also elsewhere on the board
unnamed 51: D13.2 (A); also elsewhere on the board
unnamed 52: D13.1 (K); also elsewhere on the board

## KiCad design BMS Busbar Board/BMS Busbar Board/BMS Busbar Board.kicad_pcb

Board: 2 copper layers, 389.4 x 127.6 mm, 11 parts (0 on the bottom side), 11 nets.

Parts:
F1, F2, F3, F4, F5, F6, F7, F8, F9: Littlefuse 1812L050/30; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
J1, J2: 84952-5; TE_84952-5

Connections:
/cell_0_minus: F8.1, F9.1
/cell_5_plus: F1.1, F2.1
/v_sense_cell_0: F7.2, J2.3
/v_sense_cell_1: F6.2, J2.4
/v_sense_cell_2: F5.2, J2.5
/v_sense_cell_3: F4.2, J1.1
/v_sense_cell_4: F3.2, J1.2
/v_sense_cell_5: F2.2, J1.3
/v_sense_minus: F8.2, J2.2
V_high: F1.2, J1.4
V_low: F9.2, J2.1

## KiCad design BMS/TempSenseBoard/TempSenseBoard.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12: 1 uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX5R8BB105; Digi PN 311-1445-1-ND
J2, J4: 512810598
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12: TMP1075D; SO-8_3.9x4.9mm_P1.27mm; MFG PN TMP1075DR; Digi PN 296-51833-1-ND
U13: DS18B20Z+; 21-0041B_8_MXM; MFG PN DS18B20Z+; Digi PN DS18B20Z+-ND

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, J2.5, U1.8 (V+), U2.7 (A0), U2.8 (V+), U3.6 (A1), U3.7 (A0), U3.8 (V+), U4.5 (A2), U4.6 (A1), U4.7 (A0), U4.8 (V+), U5.5 (A2), U5.7 (A0), U5.8 (V+), U6.8 (V+), U7.6 (A1), U7.8 (V+), U8.5 (A2), U8.6 (A1), U8.8 (V+), U9.8 (V+), U10.5 (A2), U10.8 (V+), U11.6 (A1), U11.8 (V+), U12.8 (V+)
/ALERT: J2.4, U1.3 (ALERT), U2.3 (ALERT), U3.3 (ALERT), U4.3 (ALERT), U5.3 (ALERT), U6.3 (ALERT), U7.3 (ALERT), U8.3 (ALERT), U9.3 (ALERT), U10.3 (ALERT), U11.3 (ALERT), U12.3 (ALERT)
/DQ: J4.5, U13.4 (DQ)
/SCL: J2.2, U1.2 (SCL), U2.2 (SCL), U3.2 (SCL), U4.2 (SCL), U5.2 (SCL), U6.2 (SCL), U7.2 (SCL), U8.2 (SCL), U9.2 (SCL), U10.2 (SCL), U11.2 (SCL), U12.2 (SCL), U12.7 (A0)
/SDA: J2.3, U1.1 (SDA), U2.1 (SDA), U3.1 (SDA), U4.1 (SDA), U5.1 (SDA), U6.1 (SDA), U6.6 (A1), U7.1 (SDA), U8.1 (SDA), U9.1 (SDA), U9.7 (A0), U10.1 (SDA), U11.1 (SDA), U11.7 (A0), U12.1 (SDA)
unnamed: J4.1, U13.5 (GND)
V-: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, J2.1, U1.4 (GND), U1.5 (A2), U1.6 (A1), U1.7 (A0), U2.4 (GND), U2.5 (A2), U2.6 (A1), U3.4 (GND), U3.5 (A2), U4.4 (GND), U5.4 (GND), U5.6 (A1), U6.4 (GND), U6.5 (A2), U6.7 (A0), U7.4 (GND), U7.5 (A2), U7.7 (A0), U8.4 (GND), U8.7 (A0), U9.4 (GND), U9.5 (A2), U9.6 (A1), U10.4 (GND), U10.6 (A1), U10.7 (A0), U11.4 (GND), U11.5 (A2), U12.4 (GND), U12.5 (A2), U12.6 (A1)

Board: 4 copper layers, 351.0 x 120.8 mm, 27 parts (0 on the bottom side), 7 nets.
