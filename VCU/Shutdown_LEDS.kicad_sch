File: VCU/Shutdown_LEDS.kicad_sch (KiCad schematic)
At the start: 71 parts, among them Q1 AO3400A, Q2 AO3400A, Q3 AO3400A, Q4 AO3400A, Q5 AO3400A, U10 SN74HCS08DR, U13 SN74HC14DR, U15 SN74HC14DR, U16 LM555CMX

Commit message: Fixed red SMD LED fields
Parts:
- D10, D11, D2, D3, D4, D5, D6, D7, D8, D9: value QBLP631-R3A -> LTST-S270KRKT; Digi PN 1516-QBLP631-R3ACT-ND -> 160-1479-1-ND; Digi URL https://www.digikey.com/en/products/detail/qt-brightek-qtb/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 -> https://www.digikey.com/en/products/detail/liteon/LTST-S270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; MFG QTB -> Lite-On Inc.; MFG PN QBLP631-R3A -> LTST-S270KRKT
Changed lines of the file:
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@@
 			)
 		)
-		(property "Value" "QBLP631-R3A"
+		(property "Value" "LTST-S270KRKT"
 			(at 188.2775 125.73 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://www.qt-brightek.com/datasheet/QBLP631-R3A.pdf"
+		(property "Datasheet" "https://optoelectronics.liteon.com/upload/download/DS22-2000-210/LTST-S270KRKT.pdf"
 			(at 186.69 130.81 0)
 			(effects
@@
 			)
 		)
-		(property "Digi PN" "1516-QBLP631-R3ACT-ND"
+		(property "Digi PN" "160-1479-1-ND"
 			(at 186.69 130.81 0)
 			(effects
@@
 			)
 		)
-		(property "Digi URL" "https://www.digikey.com/en/products/detail/qt-brightek-qtb/QBLP631-R3A/23026406"
+		(property "Digi URL" "https://www.digikey.com/en/products/detail/liteon/LTST-S270KRKT/386895"
 			(at 186.69 130.81 0)
 			(effects
@@
 			)
 		)
-		(property "MFG" "QTB"
+		(property "MFG" "Lite-On Inc."
 			(at 186.69 130.81 0)
 			(effects
@@
 			)
 		)
-		(property "MFG PN" "QBLP631-R3A"
+		(property "MFG PN" "LTST-S270KRKT"
 			(at 186.69 130.81 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "QBLP631-R3A"
+		(property "Value" "LTST-S270KRKT"
 			(at 187.0075 87.63 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://www.qt-brightek.com/datasheet/QBLP631-R3A.pdf"
+		(property "Datasheet" "https://optoelectronics.liteon.com/upload/download/DS22-2000-210/LTST-S270KRKT.pdf"
 			(at 185.42 92.71 0)
 			(effects
@@
 			)
 		)
-		(property "Digi PN" "1516-QBLP631-R3ACT-ND"
+		(property "Digi PN" "160-1479-1-ND"
 			(at 185.42 92.71 0)
 			(effects
@@
 			)
 		)
-		(property "Digi URL" "https://www.digikey.com/en/products/detail/qt-brightek-qtb/QBLP631-R3A/23026406"
+		(property "Digi URL" "https://www.digikey.com/en/products/detail/liteon/LTST-S270KRKT/386895"
 			(at 185.42 92.71 0)
 			(effects
@@
 			)
 		)
-		(property "MFG" "QTB"
+		(property "MFG" "Lite-On Inc."
 			(at 185.42 92.71 0)
 			(effects
@@
 			)
 		)
-		(property "MFG PN" "QBLP631-R3A"
+		(property "MFG PN" "LTST-S270KRKT"
 			(at 185.42 92.71 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "QBLP631-R3A"
+		(property "Value" "LTST-S270KRKT"
 			(at 93.0275 115.57 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://www.qt-brightek.com/datasheet/QBLP631-R3A.pdf"
+		(property "Datasheet" "https://optoelectronics.liteon.com/upload/download/DS22-2000-210/LTST-S270KRKT.pdf"
 			(at 91.44 120.65 0)
 			(effects
@@
 			)
 		)
-		(property "Digi PN" "1516-QBLP631-R3ACT-ND"
+		(property "Digi PN" "160-1479-1-ND"
 			(at 91.44 120.65 0)
 			(effects
@@
 			)
 		)
-		(property "Digi URL" "https://www.digikey.com/en/products/detail/qt-brightek-qtb/QBLP631-R3A/23026406"
+		(property "Digi URL" "https://www.digikey.com/en/products/detail/liteon/LTST-S270KRKT/386895"
 			(at 91.44 120.65 0)
 			(effects
@@
 			)
 		)
-		(property "MFG" "QTB"
+		(property "MFG" "Lite-On Inc."
 			(at 91.44 120.65 0)
 			(effects
@@
 			)
 		)
-		(property "MFG PN" "QBLP631-R3A"
+		(property "MFG PN" "LTST-S270KRKT"
 			(at 91.44 120.65 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "QBLP631-R3A"
+		(property "Value" "LTST-S270KRKT"
 			(at 67.6275 214.63 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://www.qt-brightek.com/datasheet/QBLP631-R3A.pdf"
+		(property "Datasheet" "https://optoelectronics.liteon.com/upload/download/DS22-2000-210/LTST-S270KRKT.pdf"
 			(at 66.04 219.71 0)
 			(effects
@@
 			)
 		)
-		(property "Digi PN" "1516-QBLP631-R3ACT-ND"
+		(property "Digi PN" "160-1479-1-ND"
 			(at 66.04 219.71 0)
 			(effects
@@
 			)
 		)
-		(property "Digi URL" "https://www.digikey.com/en/products/detail/qt-brightek-qtb/QBLP631-R3A/23026406"
+		(property "Digi URL" "https://www.digikey.com/en/products/detail/liteon/LTST-S270KRKT/386895"
 			(at 66.04 219.71 0)
 			(effects
@@
 			)
 		)
-		(property "MFG" "QTB"
+		(property "MFG" "Lite-On Inc."
 			(at 66.04 219.71 0)
 			(effects
@@
 			)
 		)
-		(property "MFG PN" "QBLP631-R3A"
+		(property "MFG PN" "LTST-S270KRKT"
 			(at 66.04 219.71 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "QBLP631-R3A"
+		(property "Value" "LTST-S270KRKT"
 			(at 126.0475 194.31 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://www.qt-brightek.com/datasheet/QBLP631-R3A.pdf"
+		(property "Datasheet" "https://optoelectronics.liteon.com/upload/download/DS22-2000-210/LTST-S270KRKT.pdf"
 			(at 124.46 199.39 0)
 			(effects
@@
 			)
 		)
-		(property "Digi PN" "1516-QBLP631-R3ACT-ND"
+		(property "Digi PN" "160-1479-1-ND"
 			(at 124.46 199.39 0)
 			(effects
@@
 			)
 		)
-		(property "Digi URL" "https://www.digikey.com/en/products/detail/qt-brightek-qtb/QBLP631-R3A/23026406"
+		(property "Digi URL" "https://www.digikey.com/en/products/detail/liteon/LTST-S270KRKT/386895"
 			(at 124.46 199.39 0)
 			(effects
@@
 			)
 		)
-		(property "MFG" "QTB"
+		(property "MFG" "Lite-On Inc."
 			(at 124.46 199.39 0)
 			(effects
@@
 			)
 		)
-		(property "MFG PN" "QBLP631-R3A"
+		(property "MFG PN" "LTST-S270KRKT"
 			(at 124.46 199.39 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "QBLP631-R3A"
+		(property "Value" "LTST-S270KRKT"
 			(at 93.0275 77.47 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://www.qt-brightek.com/datasheet/QBLP631-R3A.pdf"
+		(property "Datasheet" "https://optoelectronics.liteon.com/upload/download/DS22-2000-210/LTST-S270KRKT.pdf"
 			(at 91.44 82.55 0)
 			(effects
@@
 			)
 		)
-		(property "Digi PN" "1516-QBLP631-R3ACT-ND"
+		(property "Digi PN" "160-1479-1-ND"
 			(at 91.44 82.55 0)
 			(effects
@@
 			)
 		)
-		(property "Digi URL" "https://www.digikey.com/en/products/detail/qt-brightek-qtb/QBLP631-R3A/23026406"
+		(property "Digi URL" "https://www.digikey.com/en/products/detail/liteon/LTST-S270KRKT/386895"
 			(at 91.44 82.55 0)
 			(effects
@@
 			)
 		)
-		(property "MFG" "QTB"
+		(property "MFG" "Lite-On Inc."
 			(at 91.44 82.55 0)
 			(effects
@@
 			)
 		)
-		(property "MFG PN" "QBLP631-R3A"
+		(property "MFG PN" "LTST-S270KRKT"
 			(at 91.44 82.55 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "QBLP631-R3A"
+		(property "Value" "LTST-S270KRKT"
 			(at 68.8975 243.84 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://www.qt-brightek.com/datasheet/QBLP631-R3A.pdf"
+		(property "Datasheet" "https://optoelectronics.liteon.com/upload/download/DS22-2000-210/LTST-S270KRKT.pdf"
 			(at 67.31 248.92 0)
 			(effects
@@
 			)
 		)
-		(property "Digi PN" "1516-QBLP631-R3ACT-ND"
+		(property "Digi PN" "160-1479-1-ND"
 			(at 67.31 248.92 0)
 			(effects
@@
 			)
 		)
-		(property "Digi URL" "https://www.digikey.com/en/products/detail/qt-brightek-qtb/QBLP631-R3A/23026406"
+		(property "Digi URL" "https://www.digikey.com/en/products/detail/liteon/LTST-S270KRKT/386895"
 			(at 67.31 248.92 0)
 			(effects
@@
 			)
 		)
-		(property "MFG" "QTB"
+		(property "MFG" "Lite-On Inc."
 			(at 67.31 248.92 0)
 			(effects
@@
 			)
 		)
-		(property "MFG PN" "QBLP631-R3A"
+		(property "MFG PN" "LTST-S270KRKT"
 			(at 67.31 248.92 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "QBLP631-R3A"
+		(property "Value" "LTST-S270KRKT"
 			(at 202.2475 46.99 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://www.qt-brightek.com/datasheet/QBLP631-R3A.pdf"
+		(property "Datasheet" "https://optoelectronics.liteon.com/upload/download/DS22-2000-210/LTST-S270KRKT.pdf"
 			(at 200.66 52.07 0)
 			(effects
@@
 			)
 		)
-		(property "Digi PN" "1516-QBLP631-R3ACT-ND"
+		(property "Digi PN" "160-1479-1-ND"
 			(at 200.66 52.07 0)
 			(effects
@@
 			)
 		)
-		(property "Digi URL" "https://www.digikey.com/en/products/detail/qt-brightek-qtb/QBLP631-R3A/23026406"
+		(property "Digi URL" "https://www.digikey.com/en/products/detail/liteon/LTST-S270KRKT/386895"
 			(at 200.66 52.07 0)
 			(effects
@@
 			)
 		)
-		(property "MFG" "QTB"
+		(property "MFG" "Lite-On Inc."
 			(at 200.66 52.07 0)
 			(effects
@@
 			)
 		)
-		(property "MFG PN" "QBLP631-R3A"
+		(property "MFG PN" "LTST-S270KRKT"
 			(at 200.66 52.07 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "QBLP631-R3A"
+		(property "Value" "LTST-S270KRKT"
 			(at 66.3575 193.04 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://www.qt-brightek.com/datasheet/QBLP631-R3A.pdf"
+		(property "Datasheet" "https://optoelectronics.liteon.com/upload/download/DS22-2000-210/LTST-S270KRKT.pdf"
 			(at 64.77 198.12 0)
 			(effects
@@
 			)
 		)
-		(property "Digi PN" "1516-QBLP631-R3ACT-ND"
+		(property "Digi PN" "160-1479-1-ND"
 			(at 64.77 198.12 0)
 			(effects
@@
 			)
 		)
-		(property "Digi URL" "https://www.digikey.com/en/products/detail/qt-brightek-qtb/QBLP631-R3A/23026406"
+		(property "Digi URL" "https://www.digikey.com/en/products/detail/liteon/LTST-S270KRKT/386895"
 			(at 64.77 198.12 0)
 			(effects
@@
 			)
 		)
-		(property "MFG" "QTB"
+		(property "MFG" "Lite-On Inc."
 			(at 64.77 198.12 0)
 			(effects
@@
 			)
 		)
-		(property "MFG PN" "QBLP631-R3A"
+		(property "MFG PN" "LTST-S270KRKT"
 			(at 64.77 198.12 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "QBLP631-R3A"
+		(property "Value" "LTST-S270KRKT"
 			(at 127.3175 217.17 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://www.qt-brightek.com/datasheet/QBLP631-R3A.pdf"
+		(property "Datasheet" "https://optoelectronics.liteon.com/upload/download/DS22-2000-210/LTST-S270KRKT.pdf"
 			(at 125.73 222.25 0)
 			(effects
@@
 			)
 		)
-		(property "Digi PN" "1516-QBLP631-R3ACT-ND"
+		(property "Digi PN" "160-1479-1-ND"
 			(at 125.73 222.25 0)
 			(effects
@@
 			)
 		)
-		(property "Digi URL" "https://www.digikey.com/en/products/detail/qt-brightek-qtb/QBLP631-R3A/23026406"
+		(property "Digi URL" "https://www.digikey.com/en/products/detail/liteon/LTST-S270KRKT/386895"
 			(at 125.73 222.25 0)
 			(effects
@@
 			)
 		)
-		(property "MFG" "QTB"
+		(property "MFG" "Lite-On Inc."
 			(at 125.73 222.25 0)
 			(effects
@@
 			)
 		)
-		(property "MFG PN" "QBLP631-R3A"
+		(property "MFG PN" "LTST-S270KRKT"
 			(at 125.73 222.25 0)
 			(effects

Commit message: Fix ordering issues
* ~~Replaced QBLP631-R3A (0805) with LTST-S270KRKT (0603) for consistency and so that they fit on the footprint (0603)~~
 * Duplicated by @ronald-zhao's previous commit
* Replaced CC0603JRX7R7BB393 (C27) with CC0603JRX7R9BB393 (C28,C29,C30) for consistency, price, and higher voltage rating
* Annotated Value of C1 to `10uF 0805` to differentiate from C42
* Replaced CL10B105KP8NNNC (C2, C4, C47) with CC0603JRX7R6BB105 (C16, C20). Same footprint, better precision, consistency.
* Corrected "Stearing Position Sensor" to "Steering Position Sensor"
* Removed "N/A" Digi PNs (I think it's easier if they're just blank)
* Changed J2 Value from generic connector symbol name to SS-60400-023 (MFG PN)
* Corrected D20 Value to match MFG PN: 1092QD1-12V-ND (red) -> 1092QD5-12V-ND (Green)
  * Added text annotation to indicate that light should be Green
* Corrected D21 Value to match MFG PN: 1092QD1-12V-ND (Single Red Panel Mount) -> 12V-SB-RED-12M (Red LED Strip
* Corrected R55,R58,R59,R91 MFG PN to AC0603FR-1012KL from AC0603FR-0AC0603FR-1012KL7120KL
* Corrected LS1 Value from CPT-1625-80-SMT-TR to AI-3238-TF-LW140-R
* Corrected Digikey Link for AP63205WU-7DICT-ND
Parts:
- TP3, TP4, TP5, TP6, TP7, TP8, TP9: now left out of the parts list
Changed lines of the file:
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@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
