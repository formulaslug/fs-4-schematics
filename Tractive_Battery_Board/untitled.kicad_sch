File: Tractive_Battery_Board/untitled.kicad_sch (KiCad schematic)
At the start: 2 parts, among them J9 Current Sensor, U1 MCP6004

Commit message: Current Sensor
Parts:
- added C23, C24: 22nF, symbol Device:C
- added R13, R19: 22.1k, symbol Device:R
- added R20, R21, R22, R25: 10k, symbol Device:R
- added R23, R24, R26: 100k, symbol Device:R
Connections:
- net GND: now also R13.1, R19.1, R23.2
- net Raw_Curr_Out: now reaches J9.3
- net Raw_Curr_Out: now also U1.3 (+), C23.1
- net Raw_Curr_VRef: now reaches J9.4
- net Raw_Curr_VRef: now also U1.5 (+), C24.1
- net at U1.10 (+): now also R22.2, R25.1
- net at U1.8: now also R21.2, R26.1
- net at U1.9 (-): now also R20.2, R21.1
- net V_Curr_VRef: now reaches U1.6 (-)
- net V_Curr_VRef: now also U1.7, R20.1
- net V_Curr_Out: now reaches U1.1
- net V_Curr_Out: now also U1.2 (-), R22.1
- new net: C23.2, R13.2
- new net: C24.2, R19.2
- new net +3.3V: R24.1
- new net Current_Sensor: R26.2
- new net V_mid: R23.1, R24.2, R25.2
Other:
- note added: "1/(2 * pi * 22,100* 22 * 10^(-9)) = ~327.3Hz"
- note added: "Keep the Vmid trace short and away from noisy switching nodes"
- note added: "V_mid is a reference buffer for the signal"
- moved on the sheet: J9, U1A, U1B, U1C

Commit message: Shutdown driver relays and diodes fixed + some diff amp work
Parts:
- added R29: R, symbol Device:R
- added unit 4 of U1
- added unit 5 of U1
- R20, R21, R22, R25: value 10k -> R
- R23, R24, R26: value 100k -> R
Connections:
- net +3.3V is gone; now on net GND: R24.1
- net +5V: now also U1.4 (V+)
- net GND: now also C23.2, C24.2, R29.1, U1.11 (V-); no longer R13.1, R19.1, R23.2
- net Raw_Curr_Out: now also R13.2; no longer C23.1, U1.3 (+)
- net Raw_Curr_VRef: now also R19.2; no longer C24.1, U1.5 (+)
- net V_Curr_Out: now also R26.1
- net V_Curr_VRef: now also R23.1, R25.1; no longer R20.1
- net Current_Sensor: no longer names the net of R26.2
- net Current_Sensor: now also R29.2, U1.12 (+)
- removed net V_mid: R23.1, R24.2, R25.2
- new net: R21.1, R25.2, U1.13 (-)
- new net: R23.2, R24.2, U1.10 (+)
- new net: R20.1, R22.2, U1.9 (-)
- new net: C23.1, R13.1, U1.3 (+)
- new net: C24.1, R19.1, U1.5 (+)
- new net V_Out_Negative: R21.2, U1.14
- new net V_Out_Positive: R20.2, U1.8
Other:
- note added: "Document all the maffs"
- note added: "RC Filter --> 1/(2 * pi * 22,100* 22 * 10^(-9)) = ~327.3Hz"
- note added: "V_out = A (V_max - V_min) = A = gain = V_out_max = 2.5V + (0.625 * 900A/300A) = 4.375V V_out_min = 2.5V + (0.625 * 0A/300A) = 2.5V V_in = 5V"
- note removed: "1/(2 * pi * 22,100* 22 * 10^(-9)) = ~327.3Hz"
- note removed: "Keep the Vmid trace short and away from noisy switching nodes"
- note removed: "V_mid is a reference buffer for the signal"
- moved on the sheet: C23, C24, R13, R19, U1A, U1B, U1C

Commit message: TBB V1
Parts:
- added R30: 10k, symbol Device:R
- R20, R21, R24, R29: value R -> 178k
- R22, R23, R25, R26: value R -> 100k
Connections:
- net +5V: now also J9.4; no longer J9.1
- net GND: now also J9.3, R30.2; no longer J9.2
- net Raw_Curr_Out: now also J9.2, R30.1; no longer J9.3
- net Raw_Curr_VRef: now also J9.1; no longer J9.4
- net V_Out_Negative: now also R20.2, U1.8; no longer R21.2, U1.14
- net V_Out_Positive: now also R21.2, U1.14; no longer R20.2, U1.8
Other:
- note added: "V_out = A (V_max - V_min) = A = gain = V_out/(V_ref-V_curr_out) = 3.3 / 1.875 = 1.76 V_out = 0 < V < 3.3V V_curr_out = 2.5V + (0.625 * 900A/300A) = 4.375V OR 2.5V + (0.625 * -900A/300A) = 0.625V V_ref = 2.5V + (0.625 * 0A/300A) = 2.5V"
- note removed: "V_out = A (V_max - V_min) = A = gain = V_out_max = 2.5V + (0.625 * 900A/300A) = 4.375V V_out_min = 2.5V + (0.625 * 0A/300A) = 2.5V V_in = 5V"
- moved on the sheet: J9, R20, R24, U1C

Commit message: changed mosfets -> relay drivers, E-meters fixed, BMS shutdown WIP
Other:
- note added: "Ask Wesley if we want the raw signal"
Changed lines of the file:
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@@
 	(generator_version "9.0")
 	(paper "B")
+	(text "Ask Wesley if we want the raw signal\n"
+		(exclude_from_sim no)
+		(at 48.768 28.194 0)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+		)
+	)
 	(text "Document all the maffs"
 		(exclude_from_sim no)
@@
 	)
 	(junction
+		(at 38.1 76.2)
+		(diameter 0)
+		(color 0 0 0 0)
+	)
+	(junction
 		(at 99.06 73.66)
 		(diameter 0)
@@
 	)
 	(junction
+		(at 49.53 50.8)
+		(diameter 0)
+		(color 0 0 0 0)
+	)
+	(junction
 		(at 143.51 111.76)
 		(diameter 0)
@@
 	(wire
 		(pts
-			(xy 43.18 50.8) (xy 58.42 50.8)
+			(xy 43.18 50.8) (xy 49.53 50.8)
 		)
 		(stroke
@@
 	(wire
 		(pts
+			(xy 38.1 86.36) (xy 39.37 86.36)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 99.06 73.66) (xy 109.22 73.66)
 		)
@@
 	(wire
 		(pts
+			(xy 49.53 33.02) (xy 49.53 50.8)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 43.18 50.8) (xy 43.18 52.07)
 		)
@@
 	(wire
 		(pts
+			(xy 49.53 50.8) (xy 58.42 50.8)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 170.18 71.12) (xy 170.18 60.96)
 		)
@@
 		)
 		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
+			(xy 38.1 76.2) (xy 38.1 86.36)
+		)
+		(stroke

Commit message: minor tweaks
Parts:
- R20, R21, R29: value 178k -> 176k
Other:
- note added: "A = gain = V_out/(V_ref-V_curr_out) = 3.3 / 1.875 = 1.76 V_out = 0 < V < 3.3V V_curr_out = 2.5V + (0.625 * 900A/300A) = 4.375V OR 2.5V + (0.625 * -900A/300A) = 0.625V V_ref = 2.5V + (0.625 * 0A/300A) = 2.5V"
- note removed: "V_out = A (V_max - V_min) = A = gain = V_out/(V_ref-V_curr_out) = 3.3 / 1.875 = 1.76 V_out = 0 < V < 3.3V V_curr_out = 2.5V + (0.625 * 900A/300A) = 4.375V OR 2.5V + (0.625 * -900A/300A) = 0.625V V_ref = 2.5V + (0.625 * 0A/300A) = 2.5V"
- moved on the sheet: U1E
Changed lines of the file:
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@@
 	(text "Ask Wesley if we want the raw signal\n"
 		(exclude_from_sim no)
-		(at 48.768 28.194 0)
+		(at 49.276 30.226 0)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+		)
+	)
+	(text "Ask Wesley if we want the raw signal\n"
+		(exclude_from_sim no)
+		(at 37.084 84.836 0)
 		(effects
 			(font
@@
 		)
 	)
-	(text "V_out = A (V_max - V_min)\n	  = \n\nA = gain = V_out/(V_ref-V_curr_out) = 3.3 / 1.875 = 1.76\nV_out = 0 < V < 3.3V\nV_curr_out = 2.5V + (0.625 * 900A/300A) = 4.375V OR  2.5V + (0.625 * -900A/300A) = 0.625V\nV_ref = 2.5V + (0.625 * 0A/300A) = 2.5V\n\n"
-		(exclude_from_sim no)
-		(at 179.324 132.588 0)
+	(text "A = gain = V_out/(V_ref-V_curr_out) = 3.3 / 1.875 = 1.76\nV_out = 0 < V < 3.3V\nV_curr_out = 2.5V + (0.625 * 900A/300A) = 4.375V OR  2.5V + (0.625 * -900A/300A) = 0.625V\nV_ref = 2.5V + (0.625 * 0A/300A) = 2.5V\n\n"
+		(exclude_from_sim no)
+		(at 179.578 138.43 0)
 		(effects
 			(font
@@
 		(pts
 			(xy 152.4 99.06) (xy 158.75 99.06)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
-			(xy 38.1 86.36) (xy 39.37 86.36)
 		)
 		(stroke
@@
 		(lib_name "GND_1")
 		(lib_id "power:GND")
-		(at 26.67 114.3 0)
+		(at 41.91 114.3 0)
+		(mirror y)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(dnp no)
 		(property "Reference" "#PWR053"
-			(at 26.67 120.65 0)
+			(at 41.91 120.65 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "GND"
-			(at 26.67 119.38 0)
+			(at 41.91 119.38 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" ""
-			(at 26.67 114.3 0)
+			(at 41.91 114.3 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" ""
-			(at 26.67 114.3 0)
+			(at 41.91 114.3 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Power symbol creates a global label with name \"GND\" , ground"
-			(at 26.67 114.3 0)
+			(at 41.91 114.3 0)
 			(effects
 				(font
@@
 			)
 		)
-		(property "Value" "178k"
+		(property "Value" "176k"
 			(at 162.56 95.25 90)
 			(effects
@@
 	(symbol
 		(lib_id "Amplifier_Operational:MCP6004")
-		(at 34.29 116.84 270)
+		(at 34.29 116.84 90)
+		(mirror x)
 		(unit 5)
 		(exclude_from_sim no)
@@
 		)
 		(property "Footprint" "Package_SO:SOIC-14_3.9x8.7mm_P1.27mm"
-			(at 36.83 115.57 0)
+			(at 31.75 115.57 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" "http://ww1.microchip.com/downloads/en/DeviceDoc/21733j.pdf"
-			(at 39.37 118.11 0)
+			(at 29.21 118.11 0)
 			(effects
 				(font
@@
 			)
 		)
-		(property "Value" "178k"
+		(property "Value" "176k"
 			(at 146.05 120.6499 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "178k"
+		(property "Value" "176k"
 			(at 158.75 57.15 90)
 			(effects
@@
 		(lib_name "+5V_1")
 		(lib_id "power:+5V")
-		(at 41.91 114.3 180)
+		(at 26.67 114.3 0)
+		(mirror x)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(fields_autoplaced yes)
 		(property "Reference" "#PWR054"
-			(at 41.91 110.49 0)
+			(at 26.67 110.49 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "+5V"
-			(at 41.91 119.38 0)
+			(at 26.67 119.38 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" ""
-			(at 41.91 114.3 0)
+			(at 26.67 114.3 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" ""
-			(at 41.91 114.3 0)
+			(at 26.67 114.3 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Power symbol creates a global label with name \"+5V\""
-			(at 41.91 114.3 0)
-			(effects
-				(font
+			(at 26.67 114.3 0)
+			(effects
+				(font

Commit message: small corrections
Parts:
- R20, R21, R29: value 176k -> 178k
Other:
- note added: "10x R, C/10"
- note added: "A = gain = V_out/(V_ref-V_curr_out) = 3.3 / 1.875 = 1.76 (minimum current) V_out = 0 < V < 3.3V V_curr_out = 2.5V + (0.625 * 900A/300A) = 4.375V OR 2.5V + (0.625 * -900A/300A) = 0.625V V_ref = 2.5V + (0.625 * 0A/300A) = 2.5V"
- note added: "Document and ideal gain. note down theoretical resistor error +- 1% Resistors or BOTH 100k and 178k resistors"
- note removed: "A = gain = V_out/(V_ref-V_curr_out) = 3.3 / 1.875 = 1.76 V_out = 0 < V < 3.3V V_curr_out = 2.5V + (0.625 * 900A/300A) = 4.375V OR 2.5V + (0.625 * -900A/300A) = 0.625V V_ref = 2.5V + (0.625 * 0A/300A) = 2.5V"
- note removed: "Ask Wesley if we want the raw signal"
Changed lines of the file:
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@@
 	(generator_version "9.0")
 	(paper "B")
-	(text "Ask Wesley if we want the raw signal\n"
-		(exclude_from_sim no)
-		(at 49.276 30.226 0)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-		)
-	)
-	(text "Ask Wesley if we want the raw signal\n"
-		(exclude_from_sim no)
-		(at 37.084 84.836 0)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-		)
-	)
 	(text "Document all the maffs"
 		(exclude_from_sim no)
@@
 		)
 	)
-	(text "A = gain = V_out/(V_ref-V_curr_out) = 3.3 / 1.875 = 1.76\nV_out = 0 < V < 3.3V\nV_curr_out = 2.5V + (0.625 * 900A/300A) = 4.375V OR  2.5V + (0.625 * -900A/300A) = 0.625V\nV_ref = 2.5V + (0.625 * 0A/300A) = 2.5V\n\n"
+	(text "Document and ideal gain. \nnote down theoretical resistor error\n\n+- 1% Resistors or BOTH 100k and 178k resistors\n\n"
+		(exclude_from_sim no)
+		(at 176.784 159.004 0)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+		)
+	)
+	(text "10x R, C/10"
+		(exclude_from_sim no)
+		(at 65.786 43.18 0)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+		)
+	)
+	(text "A = gain = V_out/(V_ref-V_curr_out) = 3.3 / 1.875 = 1.76 (minimum current)\nV_out = 0 < V < 3.3V\nV_curr_out = 2.5V + (0.625 * 900A/300A) = 4.375V OR  2.5V + (0.625 * -900A/300A) = 0.625V\nV_ref = 2.5V + (0.625 * 0A/300A) = 2.5V\n\n"
 		(exclude_from_sim no)
 		(at 179.578 138.43 0)
@@
 	)
 	(junction
-		(at 38.1 76.2)
-		(diameter 0)
-		(color 0 0 0 0)
-	)
-	(junction
 		(at 99.06 73.66)
 		(diameter 0)
@@
 	)
 	(junction
-		(at 49.53 50.8)
-		(diameter 0)
-		(color 0 0 0 0)
-	)
-	(junction
 		(at 143.51 111.76)
 		(diameter 0)
@@
 	(wire
 		(pts
-			(xy 43.18 50.8) (xy 49.53 50.8)
+			(xy 43.18 50.8) (xy 58.42 50.8)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 49.53 33.02) (xy 49.53 50.8)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 43.18 50.8) (xy 43.18 52.07)
 		)
@@
 	(wire
 		(pts
-			(xy 49.53 50.8) (xy 58.42 50.8)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 170.18 71.12) (xy 170.18 60.96)
 		)
@@
 		(pts
 			(xy 166.37 99.06) (xy 172.72 99.06)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
-			(xy 38.1 76.2) (xy 38.1 86.36)
 		)
 		(stroke
@@
 			)
 		)
-		(property "Value" "176k"
+		(property "Value" "178k"
 			(at 162.56 95.25 90)
 			(effects
@@
 			)
 		)
-		(property "Value" "176k"
+		(property "Value" "178k"
 			(at 146.05 120.6499 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "176k"
+		(property "Value" "178k"
 			(at 158.75 57.15 90)
 			(effects
