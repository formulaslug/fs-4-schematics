# Repository formulaslug/fs-4-schematics (continued)

## KiCad design Tractive_Battery_Board/Tractive_Battery_Board.kicad_pcb (continued)

Parts:
C36, C37, C39: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB104; Digi PN 311-1341-1-ND
C38: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB105; Digi PN 311-1802-1-ND
C40: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CL10A226MP8NUNE; Digi PN 1276-1274-1-ND
D7, D8, D9, D10: PMEG10020ELR; Nexperia_CFP3_SOD-123W; MFG PN PMEG10020ELR-QX; Digi PN 1727-PMEG10020ELR-QXCT-ND
J10: Shutdown IL; 1054311202 - 2-Pin Molex Nano-fit; MFG PN 1054311102; Digi PN WM26073CT-ND
K1, K3: G6SK-2G; Relay_DPDT_Omron_G6SK-2G; MFG PN G6SK-2G DC24; Digi PN Z12726-ND
K2, K4: G6DN-1A; RELAY_G6DN-1A; MFG PN G6DN-1A DC12; Digi PN Z5440-ND
R42: 220k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07220KL; Digi PN YAG3579CT-ND
R43, R46: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-075K1L; Digi PN 311-5.10KHRCT-ND
R44, R47: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-0710KL; Digi PN 311-10KLDCT-ND
R45: 820k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603JR-07820KL; Digi PN 311-820KGRCT-ND
TP7: BMS_DELAY_TP; TestPoint_Pad_D1.0mm
TP8: BMS_FAULT_TP; TestPoint_Pad_D1.0mm
TP9: IMD_DELAY_TP; TestPoint_Pad_D1.0mm
TP10: Post_BSM_TP; TestPoint_Pad_D1.0mm
TP11: IMD_FAULT_TP; TestPoint_Pad_D1.0mm
TP12: Post_IMD_TP; TestPoint_Pad_D1.0mm
U9: MCP6004; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN MCP6004T-I/SL; Digi PN MCP6004T-I/SLCT-ND
U12: SN74HCS14DR; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN SN74HCS14DR; Digi PN 296-SN74HCS14DRDKR-ND
U13: SN74HCS08DR; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN SN74HCS08DR; Digi PN 296-SN74HCS08DRCT-ND
U14, U15: SZNUD3124DMT1G; SC-74-6_1.55x2.9mm_P0.95mm; MFG PN SZNUD3124DMT1G; Digi PN SZNUD3124DMT1GOSCT-ND

Connections:
+5V: C36.1, C37.1, C39.1, D7.1 (K), D8.1 (K), K1.9, K3.9, R42.1, R43.1, R45.1, R46.1, U9.4 (V+), U12.14 (VCC), U13.14 (VCC); also elsewhere on the board
+12V: K1.1, K1.4, K1.6, K3.1, K3.4, K3.6; also elsewhere on the board
/Shutdown + IMD Delay/BMS_FAULT_5V: U13.1; also elsewhere on the board
/Shutdown + IMD Delay/BMS_FAULT_DELAYED: TP8.1, U12.1, U13.3, U14.5
/Shutdown + IMD Delay/IMD_FAULT_5V: U12.4, U13.9
/Shutdown + IMD Delay/IMD_FAULT_DELAYED: TP11.1, U12.5, U13.8, U15.5
/Shutdown + IMD Delay/nBMS_FAULT_DELAYED_5V: U12.2, U14.2
/Shutdown + IMD Delay/nIMD_FAULT_DELAYED_5V: U12.6, U13.5
/Shutdown + IMD Delay/nIMD_Set: U13.6, U15.2
/nIMD_FAULT_5V: U12.3; also elsewhere on the board
GND: C36.2, C37.2, C38.2, C39.2, C40.2, D9.2 (A), D10.2 (A), K2.2, K4.2, R44.1, R47.1, U9.11 (V-), U12.7 (GND), U13.7 (GND), U14.1, U14.4, U15.1, U15.4; also elsewhere on the board
unnamed: C38.1, D7.2 (A), R42.2, TP7.1, U9.3 (+)
unnamed: C40.1, D8.2 (A), R45.2, TP9.1, U9.5 (+)
unnamed: D9.1 (K), K1.5, K2.1
unnamed: D10.1 (K), K3.5, K4.1
unnamed: J10.1, K4.8, TP12.1
unnamed: K1.7, U14.3
unnamed: K1.12, U14.6
unnamed: K2.8, K4.5, TP10.1
unnamed: K3.7, U15.3
unnamed: K3.12, U15.6
unnamed: R43.2, R44.2, U9.2 (-)
unnamed: R46.2, R47.2, U9.6 (-)
unnamed: U9.1, U13.2
unnamed: U9.7, U13.10
SH_RESET-: U13.4; also elsewhere on the board
Shutdown_In: K2.5; also elsewhere on the board
Shutdown_Out: J10.2; also elsewhere on the board
nBMS_FAULT_VCU: K1.8; also elsewhere on the board
nIMD_FAULT_VCU: K3.8; also elsewhere on the board

Notes on the sheet:
Relay Driver Contains internal resistors
IMD Delay
0.2 Startup Second Delay RC = 220k * (1 * 10^-6) = 0.22 sec t = -RC * ln(1 - 3.34/5) = 0.24 seconds
15.2 Startup Second Delay
BMS NO Relay
Outputs High When Fault Detected From BMS
Outputs Low When Fault Detected From IMD
IMD NO Relay
BMS STARTUP Delay

Parts:
C32, C33: 22nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB223; Digi PN 311-1086-1-ND
C34, C35, C42: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB104; Digi PN 311-1341-1-ND
D11, D12: PLZ3V3B-G3/H; D_SMF; MFG PN PLZ3V3B-G3/H; Digi PN PLZ3V3B-G3/HGIDKR-ND
J9: Current Sensor; 1054311104 - 4-pin Molex Nano-fit; MFG PN 1054311104; Digi PN WM26075CT-ND
R37: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-0710KL; Digi PN 311-10KLDCT-ND
R38, R39: 22.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-0722K1L; Digi PN 311-22.1KHRCT-ND
R40, R41: 62k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RMCF0603FT62K0; Digi PN RMCF0603FT62K0CT-ND
R55, R56: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-0715KL; Digi PN 311-15.0KHRCT-ND
R57: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-0710KL; Digi PN 311-10.0KHRCT-ND
R58: 237k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-07237KL; Digi PN 311-237KHRCT-ND
U9, U18: MCP6004; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN MCP6004T-I/SL; Digi PN MCP6004T-I/SLCT-ND
U10, U11: INA826AIDR; SOIC-8_3.9x4.9mm_P1.27mm; MFG PN INA826AIDR; Digi PN 296-30238-1-ND

Connections:
+5V: C34.1, C35.1, C42.1, J9.4, R57.1, U10.8 (V+), U11.8 (V+), U18.4 (V+); also elsewhere on the board
/Current Sensors + Filtering/Raw_Curr_Out: J9.2, R37.1, R38.2
/Current Sensors + Filtering/Raw_Curr_VRef: J9.1, R39.2
GND: C32.2, C33.2, C34.2, C35.2, C42.2, D11.2 (A), D12.2 (A), J9.3, R37.2, R58.2, U10.5 (V-), U11.5 (V-), U18.11 (V-); also elsewhere on the board
unnamed: R40.1, U10.2 (Rg)
unnamed: R40.2, U10.3 (Rg)
unnamed: R41.1, U11.2 (Rg)
unnamed: R41.2, U11.3 (Rg)
unnamed: R55.1, U11.7
unnamed: R56.1, U10.7
unnamed: C32.1, R38.1, U9.10 (+)
unnamed: C33.1, R39.1, U9.12 (+)
unnamed: U10.6 (Ref), U11.6 (Ref), U18.1, U18.2 (-)
unnamed: R57.2, R58.1, U18.3 (+)
V_Curr_Out: U9.8, U9.9 (-), U10.1 (-), U11.4 (+); also elsewhere on the board
V_Curr_Ref: U9.13 (-), U9.14, U10.4 (+), U11.1 (-); also elsewhere on the board
V_Out_Negative: D11.1 (K), R55.2; also elsewhere on the board
V_Out_Positive: D12.1 (K), R56.2; also elsewhere on the board

Notes on the sheet:
RC Filter --> 1/(2 * pi * 22,100* 22 * 10^(-9)) = ~327.3Hz
Document and ideal gain. note down theoretical resistor error +- 1% Resistors for the 62k resistor
GAIN = 1.78 GAIN = 1 + 49.4k/R_G R_G = ~63.333k ohms
0.2 VREF
10x R, C/10
V_out = 0 < V < 3V3 A = gain = V_out/(V_ref-V_curr_out) = 3.3 / 1.875 = 1.76 (minimum current) V_curr_out = 2.5V + (0.625 * 900A/300A) = 4.375V OR 2.5V + (0.625 * -900A/300A) = 0.625V V_ref = 2.5V + (0.625 * 0A/300A) = 2.5V

Parts:
J11: IRs Power; 1054311104 - 4-pin Molex Nano-fit; MFG PN 1054311104; Digi PN WM26075CT-ND
J12: Precharge; 1054311202 - 2-Pin Molex Nano-fit; MFG PN 1054311102; Digi PN WM26073CT-ND
K5: PR30-12V-450-1A-E; RELAY_PR30-12V-450-1A-E; MFG PN PR30-12V-450-1A-E; Digi PN 2223-PR30-12V-450-1A-E-ND
Q3: AO3400A; SOT-23; MFG PN AO3400A; Digi PN 785-1000-1-ND
R48: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-13100KL; Digi PN 13-AC0603FR-13100KLCT-ND
R49: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-0710KL; Digi PN 311-10KLDCT-ND
U12: SN74HCS14DR; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN SN74HCS14DR; Digi PN 296-SN74HCS14DRDKR-ND
U16: SZNUD3124LT1G; TSOT-23_HandSoldering; MFG PN SZNUD3124LT1G; Digi PN SZNUD3124LT1GOSCT-ND

Connections:
GND: J11.3, Q3.2 (S), R48.2, U16.2; also elsewhere on the board
IRs_Final: J11.2, J11.4, K5.A2; also elsewhere on the board
unnamed: J11.1, Q3.3 (D)
unnamed: J12.1, K5.5
unnamed: J12.2, K5.8
unnamed: K5.A1, U16.3
unnamed: Q3.1 (G), R49.2
unnamed: U12.8, U16.1
nPreCharge_Control: R48.1, R49.1, U12.9; also elsewhere on the board

Notes on the sheet:
nPrecharge_Control outputs LOW during precharge

Board: 4 copper layers, 139.7 x 63.5 mm, 178 parts (10 on the bottom side), 127 nets.

## KiCad design Temporary-Sensor-Board/Temporary-Sensor-Board.kicad_pcb

Parts:
A1: ENS220S-BLGT; XDCR_ENS220S-BLGT; PARTREV 1.0
C1, C2: 6.8pF; C_0603_1608Metric
C3, C4, C5, C8: DC; C_0603_1608Metric
C6: 1uF; C_0603_1608Metric
C7: 10nF; C_0603_1608Metric
D1: D_Small; D_0805_2012Metric
J1: Conn_ST_STDC14; PinHeader_2x07_P1.27mm_Vertical_SMD
J2: Conn_01x14_Pin; PinHeader_1x14_P1.27mm_Vertical
J3: Rightie; PinHeader_1x12_P1.27mm_Vertical
J4: Cannie; PinHeader_1x02_P2.54mm_Vertical
J5: Powerie; PinHeader_1x04_P2.54mm_Vertical
R3, R4: 2.7k; R_0603_1608Metric
TP1, TP2: Mounting; MountingHole_2.2mm_M2
U2: STM32C092KCU6; UFQFPN32_5x5_STM-M
U3: TCAN332G; SOIC-8_3.9x4.9mm_P1.27mm
U4: MCP1703Ax-330xxTT; SOT-23
U5: LP2985-1.8; SOT-23-5
Y2: 24MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm; MFG PN ECS-240-8-37B-CKY-TR; Digi PN XC3063CT-ND

Connections:
+1V8: A1.6 (~CS), A1.10 (VDD), C7.1, C8.1, J5.2, U5.5 (VOUT)
+3.3V: C3.1, C4.1, C5.1, J1.3 (VCC), J2.14, J3.12, J5.3, R3.1, R4.1, U2.4 (VDD/VDDA), U3.3 (VCC), U4.2 (VO)
+12V: D1.2 (A), J5.4
/CAN_RX: U2.15 (PB0), U3.4 (RXD)
/CAN_TX: U2.16 (PB1), U3.1 (TXD)
/I2C_SCL: A1.2 (SCL/SCLK), J3.4, R3.2, U2.19 (PA9)
/I2C_SDA: A1.4 (SDA/SDI), J3.5, R4.2, U2.13 (PA6)
/PRES_INT: A1.7 (INT/SDO), U2.11 (PA4)
/SWCLK: J1.6 (JCLK/SWCLK), U2.25 (PA14-BOOT0)
/SWDIO: J1.4 (JTMS/SWDIO), U2.24 (PA13)
/UART_RX: J1.13 (VCP_RX), J3.2, U2.8 (PA1)
/UART_TX: J1.14 (VCP_TX), J3.3, U2.7 (PA0)
/XT1: C2.1, U2.2 (PC14-OSCX_IN), Y2.3
/XT2: C1.1, U2.3 (PC15-OSCX_OUT), Y2.1
/~RST: J1.12 (~RST), U2.6 (PF2-NRST)
GND: A1.3 (GND), A1.8 (GND__1), A1.9 (GND__2), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, J1.5 (GND), J1.7 (GND), J1.11 (GNDDetect), J2.1, J3.1, J5.1, TP1.1, TP2.1, U2.5 (VSS/VSSA), U2.33 (VSS), U3.2 (GND), U4.1 (GND), U5.2 (GND), Y2.2, Y2.4
unnamed: C6.1, D1.1 (K), U4.3 (VI), U5.1 (VIN), U5.3 (ON/~OFF)
unnamed: J2.2, U2.18 (PA8)
unnamed: J2.3, U2.20 (PC6)
unnamed: J2.4, U2.21 (PA10)
unnamed: J2.5, U2.22 (PA11[PA9])
unnamed: J2.6, U2.23 (PA12[PA10])
unnamed: J2.7, U2.26 (PA15)
unnamed: J2.8, U2.27 (PB3)
unnamed: J2.9, U2.28 (PB4)
unnamed: J2.10, U2.29 (PB5)
unnamed: J2.11, U2.30 (PB6)
unnamed: J2.12, U2.31 (PB7)
unnamed: J2.13, U2.32 (PB8)
unnamed: J3.6, U2.17 (PB2)
unnamed: J3.7, U2.14 (PA7)
unnamed: J3.8, U2.12 (PA5)
unnamed: J3.9, U2.10 (PA3)
unnamed: J3.10, U2.9 (PA2)
unnamed: J3.11, U2.1 (PB9)
unnamed: J4.1, U3.7 (CANH)
unnamed: J4.2, U3.6 (CANL)
unnamed: C7.2, U5.4 (BP)

Board: 2 copper layers, 34.2 x 19.1 mm, 24 parts (1 on the bottom side), 38 nets.

## Code that names these connections

File stm32-test/cubemx/stm32-test.ioc (part):

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Mcu.Name=STM32G441KBTx
Mcu.Package=LQFP32
Mcu.UserName=STM32G441KBTx
PA11.Mode=FDCAN_Activate
PA11.Signal=FDCAN1_RX
PA12.Mode=FDCAN_Activate
PA12.Signal=FDCAN1_TX
PA13.Mode=Trace_Asynchronous_SW
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Trace_Asynchronous_SW
PA14.Signal=SYS_JTCK-SWCLK
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA4.Mode=NSS_Signal_Hard_Output
PA4.Signal=SPI1_NSS
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PA8.Mode=I2C
PA8.Signal=I2C2_SDA
PA9.Mode=I2C
PA9.Signal=I2C2_SCL
PB3.Mode=Trace_Asynchronous_SW
PB3.Signal=SYS_JTDO-SWO
PF0-OSC_IN.Mode=HSE-External-Oscillator
PF0-OSC_IN.Signal=RCC_OSC_IN
PF1-OSC_OUT.Mode=HSE-External-Oscillator
PF1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=16000000
board=custom

## Commit log (part)

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2026-01-30 More traces, rearranged parts to make cleaner traces
2026-01-31 finished traces
2026-01-31 1.12.3
    Updated Fuse Issues
2026-01-31 Rev 1.13
    Resourced HV Resistor to be of 0805 form factor for higher max working voltage and power dissipation
    edited connector symbols to correspond with pad numbers
    removed pad numbers for connectors which pad pins for mounting reasons so that PCB editor did not flag error
    added NC pin (pin 4) to DCDC so PCB editor did not flag error
2026-01-31 busbar files created
2026-02-01 copper zones added to pcb
2026-02-01 busbar schematic and pcb progress
2026-02-01 fuse footprints added
2026-02-01 Layout Rev 1.0
    Placed all components, have not wired any traces yet
2026-02-01 fixed led colors
2026-02-01 Commited HV Indicator Light
2026-02-01 SFC footprint + symbol
2026-02-02 footprints and fixed sizing
2026-02-03 trace update
2026-02-03 reoriented ground on schematic
2026-02-03 datasheet progress
2026-02-03 more datasheet progress
2026-02-03 even datasheet progress
2026-02-03 TBB Finalized V1
2026-02-03 layout update
2026-02-03 HV Layout
2026-02-04 HV rearranged + Precharge layout
2026-02-04 Formula slug title footprint added
2026-02-04 library changes WIP
2026-02-05 busboard progress (possibly wrong connector)
2026-02-05 Schematic Rev 1.13.2 Layout Rev 1.2
    Added bypass caps for op amps
    Redoing some of the lv wiring
2026-02-05 added test points for all pins
2026-02-05 more changes (part source)
2026-02-05 updated MFG field on backlight circuit inductor
2026-02-06 INA826AIDR symbol update
2026-02-06 Layout Progress
2026-02-06 Removed unused footprints, symbols and fixed library paths
2026-02-07 nanofits added correctly to library
2026-02-07 fixed relay driver choice
2026-02-07 - fixed units and DRC rules for steering wheel PCB - layout pretty much done except for dial placement
2026-02-07 added steering position sensor
2026-02-07 Layout 1.3
    Finished layout, fixed all DRC errors and warnings
2026-02-08 Added Name to finalized board
    Added name to finalized board
2026-02-08 90% TBB layout design
2026-02-08 layout changes
2026-02-08 Layout Rev 1.4.1
    Added mounting holes
2026-02-08 page setup fix
2026-02-08 trace cleanup
2026-02-09 pin changes for ethernet
2026-02-09 update cosmetic
2026-02-09 Edited layout, very much a rough draft
2026-02-09 move components significantly
2026-02-09 Added title block
2026-02-09 Fixed ground fills
2026-02-09 Datasheet/part sourcing update
2026-02-09 busbar pcb complete (with violations)
2026-02-10 Update BMS.kicad_pcb
    some isospi trace improvement
    fixed via sizes for trace widths of 20 mils
2026-02-10 fixed Vcca side
2026-02-10 gerbers
2026-02-10 TBB V1.1 (2 layers)
    has 4 layers set up, but current design was made around 2 layeres
2026-02-10 new layout changes and extra layers
2026-02-10 update schematic to match updated rj45 pinout
2026-02-10 fixed pins of 40 pin ribbon cable connector for screen
2026-02-10 Documentation for Relay and Diode
2026-02-11 more layout
2026-02-11 added missing BOM fields and added company to title block
2026-02-11 Prepared peripheral board for order
2026-02-11 updated file to cleanup vias jlc doesn't like
2026-02-12 Updated some symbol fields
2026-02-14 changed digikey info of pushbutton switches to new selection
2026-02-18 Fix ordering issues
    * ~~Replaced QBLP631-R3A (0805) with LTST-S270KRKT (0603) for consistency and so that they fit on the footprint (0603)~~
    * Duplicated by @ronald-zhao's previous commit
    * Replaced CC0603JRX7R7BB393 (C27) with CC0603JRX7R9BB393 (C28,C29,C30) for consistency, price, and higher voltage rating
    * Annotated Value of C1 to `10uF 0805` to differentiate from C42
    * Replaced CL10B105KP8NNNC (C2, C4, C47) with CC0603JRX7R6BB105 (C16, C20). Same footprint, better precision, consistency.
    * Corrected "Stearing Position Sensor" to "Steering Position Sensor"
2026-02-22 label add
    label add
2026-02-23 more schem fixes for rev
    more schem fixes for rev - added footprints to steering, no more pwr flags, better labels
2026-02-23 screw holes added (except top right)
2026-02-25 Schematic Rev 2.0
    Need to still add footprints but components selected, other symbol fields filled out
2026-02-26 setup files
2026-02-26 more erc fix
    title says it all
2026-02-26 Peripheral Board Rev 1.1 (Order 1) (#10)
    * Add project template
    Needs review, focusing on PCB layout rules
    * Added STM32 and old blocks
    Added STM 32 but didnt connect anything and added over old blocks from the old schematic
    * Added wheel speed sensor symbol
    * Connected wheel speed sensor and and strain gauge to mc
2026-02-26 Bms Rev 1.1 (Order 1) (#8)
    * prototype BMS Temp Sensor Board
    * full prototype schematic
    * Fixed addressing and removed A-PINS on config switches
    * attempt temp sensor tester board
    * TMP1075 Dev Board
    * BMS board
2026-02-26 Revert "Squashed commit of the following:"
    This reverts commit 26719c754ff0e4aa0538e63130d69984d8093f71.
2026-02-26 Repair symbol library
2026-02-26 Power Electronics Board Schematic rev 1 (#14)
    * Power Electronics Board Version 1
    This is the first revision of the power electronics board schematic. Layouts have not been done yet, awaiting review.
    * Update Power Electronics Board.kicad_sch
    * Update Power Electronics Board.kicad_pro
    * Fixing boxes not showing up
    * Power Electronics Board Schematic Update 1.1
2026-03-01 some more fixes
    some more fixes
2026-03-02 step file
    step file
2026-03-05 add full APPS sensor PN (P6T-360)
2026-03-08 made new branch for temp sense board
2026-03-11 datasheet
    datasheet
2026-03-12 more datasheet
    more
2026-03-12 add connector
    add connector
2026-03-13 new conn
    new conn
2026-03-16 re-added nanofit step to 3d library
2026-03-22 Imported board settings from VCU
    Still need to actually change the sizes of traces
2026-03-23 OvenBoard Layout 2
    made all changes requested
2026-03-26 new step
    new step file
2026-03-26 Rev 2.1.1
    just sum light trace edits nun much
2026-03-26 v1.2 with ring terminal studs
2026-03-27 v1.4 added note for 12VMP, fixed silkscreen title, fixed chud trace
2026-03-30 sum more datasheet
    more stuff
2026-03-31 added pad for cell_5_plus wire bonding
2026-03-31 whitespace fixes
    whitespace fixes
2026-04-01 more whitespace fixes
    more whitespace fixes
2026-04-01 Rev 2.3
    Updated schematic's comments, added labels for connectors
2026-04-02 connector steps
    connector steps
2026-04-03 final routing
2026-04-03 shrug
2026-04-03 new connector added
2026-04-04 added 3d models for fuses and connector
2026-04-04 layout editor setup changes
2026-04-04 fixes
    fixes
2026-04-04 2 temp sensors and CAD
2026-04-04 CAD adjustments and 0.8
2026-04-05 V1.3: SPI pins corrected + TPs, IMD Delay data table correction
2026-04-05 cappacitor references match sensors
2026-04-06 Updated Keep Out Zone For IMU
2026-04-06 board update
    board update
2026-04-07 cleanup silkscreen
2026-04-09 Update STLINK-V3MODS symbol to include pin directionality
2026-04-09 combined connectors
    combined connectors
2026-04-10 ERC fixes + HVIL circuit corrections.
2026-04-10 more layout/newconnector
    more layout/newconnector
2026-04-10 Updated to just be DIB specific items
2026-04-12 fixing drc
    fixing drc
2026-04-12 changed connector to TE_84952-5
2026-04-12 stepfile
    stepfile
2026-04-12 fixed label
    fixed label
2026-04-12 Rev 2.5.1
    More layout changes to fit into inverter box. @victorkalastirsky has 90% confirmed that the layout is okay, worried about bend radiuses for the high current connector wires. I'm worried about the spa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
2026-04-13 update board shape to rev2
2026-04-13 steering wheel board rev2
2026-04-13 BMS rev 2 changes
    - I changed pin25 to GPIO4, and replaced the GPIO1 on the temp sense connector and temp sense pullups to GPIO4.
    - I added the new busbar connectors
    What would we do with the GPIO1 pin? Add the same led that was on GPOI4 previously?
2026-04-14 Bump Rev to 2.1
2026-04-14 R2.0 Add Second CAN Transceiver, bump Rev #
2026-04-14 R2.1 Apply sch. changes to PCB Layout
    2nd CAN Transceiver (U3)
    Additional Temp Sense Connector
2026-04-14 silkscreen fix and pretty traces
2026-04-15 moved connector/can traces
    moved connector/can traces
2026-04-15 slight position change
    position change
2026-04-15 Trace Updates
2026-04-15 Revert "Layout done, missing documentation"
    This reverts commit c3ceebc9681f6c0cf3131b0774409dfcb98ecb72.
2026-04-15 Board Layout
    Accidentally pushed to TBB, reverted changes and pushed here
2026-04-15 Updated Component Documentation
2026-04-17 minor trace changes, waiting on BMS to be fixed
2026-04-17 page settings
2026-04-17 R2.1.1: Correct Ordering info for 1mm FPC Conns
2026-04-19 updated symbol field
2026-04-19 Updated SIS Connectin
2026-04-26 - Added fabrication notes to steering wheel board - Updated dates on all pages of steering wheel schematic - Updated Digikey information for pushbuttons on steering wheel schematic
2026-04-28 ready for review
2026-04-28 changed some traces
    changed some traces
2026-04-29 updated minor fixes for ordering
2026-05-01 added fixes
    addes fixes
2026-05-01 user notes plus gerbers
    user notes plus gerbers
2026-05-04 BMS Rev3.0.0: Fix balance block: use NMOS, use datasheet recommended setup
2026-05-15 WIP: BMS emergency revision schematic changes done
2026-05-15 rev 3.1
2026-05-16 Rev 2.6
    Fixed CRITICAL OP AMP INPUT ISSUE, did not change layout of big components
2026-05-16 Rev revision update
2026-05-18 Added clamping and fixed redundancy
    Adding a 3.4v zener diode and removed op amp.
2026-05-23 Rev 3
    renamed, fixed op amp LV batt
2026-05-23 add 512810598.stp connector (bms/tempsense boards, 0.5mm pitch 5-pin FPC)
2026-05-24 Updated resistor values for I2C pullup
2026-05-25 to be changed to hierarchal sheets
2026-05-25 Rev 1.1
    - added symbol and footprint for gate driver IC
    - added hierarchical sheets and labels for both SR and gate driver
    - added footprint for B66368B1020T001 Bobbin (DIPS4064W80P508L5450H4090Q20N)
2026-05-28 Rev 1.3
    - Renamed Gate Driver Page to LLC Controller/Gate Driver
    - Added Footprint, Datasheet, and Description for UCC256614DDBR (LLC Controller/Gate Driver)
    Note: The LLC Controller IC does not have Pin 2, 13. Footprint does not reflect this
2026-05-29 Rev 1.5
    - Changed UCC256614DDBR to UCC256612DDBR
    - Finished LLC Controller Page (?)
    - Will need to calculate resistor, capacitor values
2026-05-29 Rev 1.6
    Root (page 1)
    - Renamed input connectors to HV
    - Added Resonant Cap value
    - Added information about the transformer, windings, inductance
    - Changed names of input/output voltage
    - Added smoothing cap on output
2026-06-01 Rev 1.7
    - Finished Sync Rect
    - updated root page to match sync rect
2026-06-03 Fixed SPI trace for BME688
2026-06-07 remove old empty charger project
2026-06-12 VCCP_min spec comments
    Changes:
    - Added VCCP_min spec that are based on UVLO to LLC Controller page
    Summary:
    - UVLO Rising 7.5 nom
    - UVLO Falling 6.8 nom
2026-06-12 Comments added for OVP/OTP
    - Added comments on using Tertiary winding for VCCP
    - Added comments on OVP/OTP trip voltages
2026-06-13 Changed transformer to include tertiary winding
    Notes:
    - Schematic is not updated for connections (my drag selection does not work on my computer 😡 )
