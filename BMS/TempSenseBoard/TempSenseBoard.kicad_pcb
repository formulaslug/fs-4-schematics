File: BMS/TempSenseBoard/TempSenseBoard.kicad_pcb (KiCad board)
At the start: 2 copper layers, 0 parts

Commit message: just a few traces, footprints
Parts:
- added C10: 0.01 uF, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (229.7, 199.5)
- added C11: 0.01 uF, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (229.7, 202.0)
- added C12: 0.01 uF, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (229.7, 204.5)
- added C13: 0.01 uF, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (229.7, 207.0)
- added C2: 0.01 uF, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (221.0, 199.5)
- added C3: 0.01 uF, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (221.0, 202.0)
- added C4: 0.01 uF, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (221.0, 204.5)
- added C5: 0.01 uF, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (221.0, 207.0)
- added C6: 0.01 uF, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (225.4, 199.5)
- added C7: 0.01 uF, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (225.4, 202.0)
- added C8: 0.01 uF, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (225.4, 204.5)
- added C9: 0.01 uF, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (225.4, 207.0)
- added J1: 5019510550, FS_4_Global_Footprint_Library:CON_5019510550, F.Cu at (244.5, 65.2)
- added J3: 5019510550, FS_4_Global_Footprint_Library:CON_5019510550, F.Cu at (144.5, 65.2)
- added U1: TMP1075D, Package_SO:SO-8_3.9x4.9mm_P1.27mm, F.Cu at (205.1, 181.8)
- added U10: TMP1075D, Package_SO:SO-8_3.9x4.9mm_P1.27mm, F.Cu at (230.5, 181.8)
- added U11: TMP1075D, Package_SO:SO-8_3.9x4.9mm_P1.27mm, F.Cu at (230.5, 188.4)
- added U12: TMP1075D, Package_SO:SO-8_3.9x4.9mm_P1.27mm, F.Cu at (230.5, 195.0)
- added U13: DS18B20Z+, FS_4_Global_Footprint_Library:21-0041B_8_MXM, F.Cu at (204.5, 124.8)
- added U2: TMP1075D, Package_SO:SO-8_3.9x4.9mm_P1.27mm, F.Cu at (205.1, 188.4)
- added U3: TMP1075D, Package_SO:SO-8_3.9x4.9mm_P1.27mm, F.Cu at (205.1, 195.0)
- added U4: TMP1075D, Package_SO:SO-8_3.9x4.9mm_P1.27mm, F.Cu at (213.6, 181.8)
- added U5: TMP1075D, Package_SO:SO-8_3.9x4.9mm_P1.27mm, F.Cu at (213.6, 188.4)
- added U6: TMP1075D, Package_SO:SO-8_3.9x4.9mm_P1.27mm, F.Cu at (213.6, 195.0)
- added U7: TMP1075D, Package_SO:SO-8_3.9x4.9mm_P1.27mm, F.Cu at (222.0, 181.8)
- added U8: TMP1075D, Package_SO:SO-8_3.9x4.9mm_P1.27mm, F.Cu at (222.0, 188.4)
- added U9: TMP1075D, Package_SO:SO-8_3.9x4.9mm_P1.27mm, F.Cu at (222.0, 195.0)
Routing:
- net Net-(U13-DQ): track 0.00 -> 72.7 mm
Other:
- board outline added: 351 x 131 mm

Commit message: 2 temp sensors and CAD
Parts:
- moved C4 112.5 mm to (169.0, 104.8), turned to -90 degrees
- moved J1 100.0 mm to (144.5, 65.2)
- moved J3 100.0 mm to (244.5, 65.2)
- moved U4 91.4 mm to (164.5, 104.8)
- moved C3 38.1 mm to (183.4, 196.0)
Routing:
- net Net-(U13-GND): track 0.00 -> 100.9 mm, vias 0 -> 2
- net V-: track 0.00 -> 63.9 mm, vias 0 -> 2
- net +5V: track 0.00 -> 55.8 mm
- net /SCL: track 0.00 -> 54.5 mm, vias 0 -> 2
- net /SDA: track 0.00 -> 49.7 mm
- net Net-(U13-DQ): track 72.7 -> 100.9 mm

Commit message: test fit in CAD with 2 temp sensors and 2 connectors
Routing:
- net V-: track 63.9 -> 72.7 mm
- net /SCL: track 54.5 -> 62.3 mm
- net Net-(U13-GND): track 100.9 -> 96.5 mm, vias 2 -> 0
- net Net-(U13-DQ): track 100.9 -> 97.6 mm

Commit message: CAD adjustments and 0.8
Parts:
- moved J1 0.25 mm to (144.5, 65.0)
- moved J3 0.25 mm to (244.5, 65.0)
Routing:
- net V-: track 72.7 -> 64.1 mm
- net /SCL: track 62.3 -> 55.0 mm

Commit message: 4 layer
Parts:
- moved C2 203.5 mm to (64.5, 88.2), turned to 180 degrees
- moved C1 187.2 mm to (369.0, 84.8), turned to -90 degrees
- moved U1 186.6 mm to (364.5, 84.8)
- moved U2 174.7 mm to (64.5, 84.8)
- moved C5 100.4 mm to (185.8, 203.8)
- moved C4 92.3 mm to (169.0, 104.8), turned to -90 degrees
- renumbered C2 to C1, C9 to C10, C10 to C11, C11 to C12, C13 to C2, C12 to C3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
Routing:
- net V-: track 64.1 -> 4.17 mm, vias 2 -> 3
- net /ALERT: track 0.00 -> 53.5 mm, vias 0 -> 2
- net +5V: track 56.0 -> 9.60 mm, vias 0 -> 1
- net Net-(U13-GND): vias 0 -> 1
- added copper zone on In2.Cu, net +5V
- added copper zone on In1.Cu, net V-
Other:
- copper layers 2 -> 4

Commit message: Update TempSenseBoard.kicad_pcb
Parts:
- moved C3 41.0 mm to (190.1, 193.8)
- moved U11 40.4 mm to (257.9, 218.1)
- moved U7 38.0 mm to (231.8, 218.5)
- moved C11 36.4 mm to (258.6, 221.5)
- moved U5 35.5 mm to (186.2, 211.0)
- moved C10 28.4 mm to (236.9, 181.0)
- moved C9 24.0 mm to (207.5, 188.5)
- moved U6 22.9 mm to (209.5, 217.5)
- moved C7 21.2 mm to (238.4, 216.2)
- moved U9 19.7 mm to (207.0, 182.2)
- moved C12 16.0 mm to (245.4, 205.0)
- moved U3 15.5 mm to (190.5, 190.0)
- moved U12 14.7 mm to (244.5, 199.5)
- moved U8 13.2 mm to (219.2, 201.2)
- moved C6 11.7 mm to (210.2, 211.5)
Routing:
- net /ALERT: track 53.5 -> 157.5 mm, vias 2 -> 3
- net /SCL: track 55.2 -> 152.2 mm, vias 2 -> 6
- net /SDA: track 49.9 -> 145.3 mm, vias 0 -> 2
- net V-: track 4.17 -> 16.7 mm, vias 3 -> 8
- net +5V: track 9.60 -> 13.4 mm, vias 1 -> 4
- net Net-(U13-GND): vias 1 -> 0
