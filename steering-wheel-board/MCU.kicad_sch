File: steering-wheel-board/MCU.kicad_sch (KiCad schematic)
At the start: 18 parts, among them J2 FTSH-107-01-F-DV-K-P-TR, SW1 Y97KT23B5NAFP, U3 ISO1044BD, U5 STM32G441KBTx, Y1 ECS-240-8-37B-CKY-TR

Commit message: updated symbol fields
Parts:
- C16, C17: Digi PN (none) -> 311-3874-1-ND; Digi URL (none) -> https://www.digikey.com/en/products/detail/yageo/CC0603DRNP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; Digikey Link https://www.digikey.com/en/products/detail/yageo/CC0603DRNP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 -> (none); Digikey Part Number 311-3874-1-ND -> (none); MFG (none) -> Yageo; MFG PN (none) -> CC0603DRNPO9BN6R8; Manufacturer Yageo -> (none); Manufacturer Part Number CC0603DRNPO9BN6R8 -> (none)
- C18, C6, C7: Digi PN (none) -> 490-5798-1-ND; Digi URL (none) -> https://www.digikey.com/en/products/detail/murata-electroni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; Digikey Link https://www.digikey.com/en/products/detail/murata-electroni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 -> (none); Digikey Part Number 490-5798-1-ND -> (none); MFG (none) -> Murata Electronics; MFG PN (none) -> GCJ188R71H104KA12D; Manufacturer Murata Electronics -> (none); Manufacturer Part Number GCJ188R71H104KA12D -> (none)
- C19: Digi PN (none) -> 1276-CL10A106KO8NQNCCT-ND; Digi URL (none) -> https://www.digikey.com/en/products/detail/samsung-electro-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; Digikey Link https://www.digikey.com/en/products/detail/samsung-electro-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 -> (none); Digikey Part Number 1276-CL10A106KO8NQNCCT-ND -> (none); MFG (none) -> Samsung Electro-Mechanics; MFG PN (none) -> CL10A106KO8NQNC; Manufacturer Samsung Electro-Mechanics -> (none); Manufacturer Part Number CL10A106KO8NQNC -> (none)
- C20, C21, C23: Digi PN (none) -> 311-1344-1-ND; Digi URL (none) -> https://www.digikey.com/en/products/detail/yageo/CC0603KRX7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; Digikey Link https://www.digikey.com/en/products/detail/yageo/CC0603KRX7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 -> (none); Digikey Part Number 311-1344-1-ND -> (none); MFG (none) -> Yageo; MFG PN (none) -> CC0603KRX7R9BB104; Manufacturer Yageo -> (none); Manufacturer Part Number CC0603KRX7R9BB104 -> (none)
- C22: Digi PN (none) -> 1276-CL10B105KB9VPJCCT-ND; Digi URL (none) -> https://www.digikey.com/en/products/detail/samsung-electro-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; Digikey Link https://www.digikey.com/en/products/detail/samsung-electro-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 -> (none); Digikey Part Number 1276-CL10B105KB9VPJCCT-ND -> (none); MFG (none) -> Samsung Electro-Mechanics; MFG PN (none) -> CL10B105KB9VPJC; Manufacturer Samsung Electro-Mechanics -> (none); Manufacturer Part Number CL10B105KB9VPJC -> (none)
- FB1: Digi PN (none) -> 4816-FCM1608KF-601T03CT-ND; Digi URL (none) -> https://www.digikey.com/en/products/detail/tai-tech-advance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; Digikey Link https://www.digikey.com/en/products/detail/tai-tech-advance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 -> (none); Digikey Part Number 4816-FCM1608KF-601T03CT-ND -> (none); MFG (none) -> TAI-TECH Advanced Electronics Co., Ltd.; MFG PN (none) -> FCM 1608KF-601T03; Manufacturer TAI-TECH Advanced Electronics Co., Ltd. -> (none); Manufacturer Part Number FCM 1608KF-601T03 -> (none)
- J2: Digi PN (none) -> SAM13170CT-ND; Digi URL (none) -> https://www.digikey.com/en/products/detail/samtec-inc/FTSH-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; Digikey Link https://www.digikey.com/en/products/detail/samtec-inc/FTSH-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 -> (none); Digikey Part Number SAM13170CT-ND -> (none); MFG (none) -> Samtec Inc.; MFG PN (none) -> FTSH-107-01-F-DV-K-P-TR; Manufacturer Samtec Inc. -> (none); Manufacturer Part Number FTSH-107-01-F-DV-K-P-TR -> (none)
- R1: Digi PN (none) -> 311-10.0KHRCT-ND; Digi URL (none) -> https://www.digikey.com/en/products/detail/yageo/RC0603FR-0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; Digikey Link https://www.digikey.com/en/products/detail/yageo/RC0603FR-0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 -> (none); Digikey Part Number 311-10.0KHRCT-ND -> (none); MFG (none) -> YAGEO; MFG PN (none) -> RC0603FR-0710KL; Manufacturer YAGEO -> (none); Manufacturer Part Number RC0603FR-0710KL -> (none)
- R2: Digi PN (none) -> 311-4.70KHRCT-ND; Digi URL (none) -> https://www.digikey.com/en/products/detail/yageo/RC0603FR-0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; Digikey Link https://www.digikey.com/en/products/detail/yageo/RC0603FR-0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 -> (none); Digikey Part Number 311-4.70KHRCT-ND -> (none); MFG (none) -> YAGEO; MFG PN (none) -> RC0603FR-074K7L; Manufacturer YAGEO -> (none); Manufacturer Part Number RC0603FR-074K7L -> (none)
- SW1: Digikey Link https://www.digikey.com/en/products/detail/c-k/y97kt23b5naf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 -> (none); Digikey Part Number 108-Y97KT23B5NAFPCT-ND -> (none); MFG PN (none) -> Y97KT23B5NAFP; Manufacturer C&K -> (none); Manufacturer Part Number Y97KT23B5NAFP -> (none)
- U3: Digi PN (none) -> 296-ISO1044BDRCT-ND; Digi URL (none) -> https://www.digikey.com/en/products/detail/texas-instrument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; Digikey Link https://www.digikey.com/en/products/detail/texas-instrument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 -> (none); Digikey Part Number 296-ISO1044BDRCT-ND -> (none); MFG (none) -> Texas Instruments; MFG PN (none) -> ISO1044BDR; Manufacturer Texas Instruments -> (none); Manufacturer Part Number ISO1044BDR -> (none)
- U5: Digi PN (none) -> 497-STM32G441KBT6-ND; Digi URL (none) -> https://www.digikey.com/en/products/detail/stmicroelectroni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; Digikey Link https://www.digikey.com/en/products/detail/stmicroelectroni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 -> (none); Digikey Part Number 497-STM32G441KBT6-ND -> (none); MFG (none) -> STMicroelectronics; MFG PN (none) -> STM32G441KBT6; Manufacturer STMicroelectronics -> (none); Manufacturer Part Number STM32G441KBT6 -> (none)
- Y1: Digi PN (none) -> XC3063CT-ND; Digi URL (none) -> https://www.digikey.com/en/products/detail/ecs-inc/ECS-240-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; Digikey Link https://www.digikey.com/en/products/detail/ecs-inc/ECS-240-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 -> (none); Digikey Part Number XC3063CT-ND -> (none); MFG (none) -> ECS; MFG PN (none) -> ECS-240-8-37B-CKY-TR; Manufacturer ECS -> (none); Manufacturer Part Number ECS-240-8-37B-CKY-TR -> (none)

Commit message: added nanofits for buttons
Other:
- note added: "GNDDETECT"
Changed lines of the file:
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@@
+		)
+	)
+	(text "GNDDETECT"
+		(exclude_from_sim no)
+		(at 158.496 138.176 0)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify left bottom)
 		)
 	)
@@
 		(effects
 			(font
-				(size 1.27 1.27)
-			)
-			(justify left bottom)
-		)
-	)
-	(label "GNDDETECT"
-		(at 158.75 138.43 0)
-		(effects
-			(font

Commit message: - changed 47u and 10u caps for DCDC to 0805 per Cole's request - added low pass filters to rotary switches - changed rotary switch symbols per Cole's request - made panel mount button symbols DNP - removed the CAN termination stuff that Sam said wouldn't work - set junction size to default per Wesley's request - minor styling/readability fixes
Other:
- note added: "MCU"
- moved on the sheet: C6, C7, U3

Commit message: added test points to MCU, layout work
Parts:
- added TP1, TP2, TP3, TP4, TP5: TestPoint, TestPoint:TestPoint_Pad_1.0x1.0mm, symbol Connector:TestPoint
Connections:
- net at U5.18 (PA8): now also TP1.1
- net at U5.19 (PA9): now also TP2.1
- net at U5.20 (PA10): now also TP3.1
- net at U5.28 (PB5): now also TP4.1
- net at U5.29 (PB6): now also TP5.1
- no-connect marks 9 -> 4
