# Repository formulaslug/fs-4-schematics (continued)

## KiCad design VCU/VCU.kicad_pcb (continued)

Parts:
C6, C7: 0.015uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R9BB153; Digi PN 311-1430-1-ND
C8, C9: 1.8nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603FRNPO9BN182; Digi PN 13-CC0603FRNPO9BN182CT-ND
C10, C11, C12, C13, C14, C15: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603JRX7R9BB104; Digi PN 311-1779-1-ND
C16: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603JRX7R6BB105; Digi PN 311-3484-1-ND
D1, D22: PMEG10020ELR; Nexperia_CFP3_SOD-123W; MFG PN PMEG10020ELR-QX; Digi PN 1727-PMEG10020ELR-QXCT-ND
K2: G6SK-2G; Relay_DPDT_Omron_G6SK-2G; MFG PN G6SK-2G DC24; Digi PN Z12726-ND
K3: G6DN-1A; RELAY_G6DN-1A; MFG PN G6DN-1A DC12; Digi PN Z5440-ND
R1, R2, R11, R12, R17, R20: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-0710KL; Digi PN 311-10KLDCT-ND
R3, R8: 200k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07200KL; Digi PN YAG3575CT-ND
R4, R5, R9, R10: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-13100KL; Digi PN 13-AC0603FR-13100KLCT-ND
R6, R7: 220k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07220KL; Digi PN YAG3579CT-ND
R13: 191k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07191KL; Digi PN 13-AC0603FR-07191KLCT-ND
R14: 120k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07120KL; Digi PN YAG3562CT-ND
R15: 9.53k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-079K53L; Digi PN 13-AC0603FR-079K53LCT-ND
R16: 169k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07169KL; Digi PN 13-AC0603FR-07169KLCT-ND
R18: 430k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07430KL; Digi PN 13-AC0603FR-07430KLCT-ND
R19: 5.23k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-075K23L; Digi PN 13-AC0603FR-075K23LCT-ND
RV1, RV2: 3296W_10K; Potentiometer_Bourns_3296W_Vertical; MFG PN 3296W-1-103LF; Digi PN 3296W-103LF-ND
SW1: 61-6441.4047; MFG PN 61-6441.4047; Digi PN 1948-1780-ND; not fitted
SW2: A165E-S; MFG PN A165E-S; Digi PN Z8879-ND; not fitted
SW3: Typ- 505; MFG PN TYPE 505; not fitted
TP1, TP2: TestPoint; TestPoint_Pad_D1.0mm
U3: HASS-300S; MFG PN HASS 300-S; Digi PN 398-1065-ND; not fitted
U4, U5: X05PSA02000P18; MFG PN X05PSA02000P18; not fitted
U6, U7, U8, U11: MCP6004; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN MCP6004T-I/SL; Digi PN MCP6004T-I/SLCT-ND
U9, U12: SN74HCS32DR; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN SN74HCS32DR; Digi PN 296-SN74HCS32DRCT-ND
U10: SN74HCS08DR; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN SN74HCS08DR; Digi PN 296-SN74HCS08DRCT-ND
U13: SN74HC14DR; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN SN74HC14DR; Digi PN 296-1194-1-ND
U14: SZNUD3124DMT1G; SC-74-6_1.55x2.9mm_P0.95mm; MFG PN SZNUD3124DMT1G; Digi PN SZNUD3124DMT1GOSCT-ND

Connections:
+5V: C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, R13.2, R15.2, R19.2, RV1.1, RV2.1, U6.4 (V+), U7.4 (V+), U8.4 (V+), U9.14 (VCC), U11.4 (V+), U12.14 (VCC); also elsewhere on the board
+12V: K2.1, K2.6, K2.9, U4.3 (VCC), U5.3 (VCC); also elsewhere on the board
/Current_Analog_Raw: R7.2, R11.1, U3.2 (Vout); also elsewhere on the board
/Current_Vref_Raw: R6.2, R12.1, U3.1 (Vref); also elsewhere on the board
/Front_Brake_Raw: R5.2, R10.2, U5.1 (Vout); also elsewhere on the board
/MCU/BSDP_Fault: TP2.1, U11.8, U13.13, U14.5; also elsewhere on the board
/Rear_Brake_Raw: R4.2, R9.1, U4.1 (Vout); also elsewhere on the board
/Reset_Button: U10.12; also elsewhere on the board
/Shutdown_VCU/BSPD_Delay_Threshold: R19.1, R20.2, U11.9 (-)
/Shutdown_VCU/BSPD_Fault_nDelayed: D1.1 (K), R18.2, TP1.1, U9.8
/Shutdown_VCU/BSPD_Set: U10.11, U14.2
/Shutdown_VCU/Brake_Current_Sensor_Fault: U9.3, U9.10
/Shutdown_VCU/Current_Sensor_Open: U6.14, U12.5
/Shutdown_VCU/Current_Sensor_Short: U6.8, U12.4
/Shutdown_VCU/Diff_Current_Output: R8.2, U6.1, U6.5 (+)
/Shutdown_VCU/Front_Brake_Open: U11.1, U12.13
/Shutdown_VCU/Front_Brake_Short: U11.7, U12.12
/Shutdown_VCU/Hard_Braking: U9.11, U10.5
/Shutdown_VCU/Hard_Front_Brake: U7.1, U9.13
/Shutdown_VCU/Hard_Rear_Brake: U7.7, U9.12
/Shutdown_VCU/High_Current_Output: U6.7, U10.4
/Shutdown_VCU/High_Current_Threshold: R13.1, R14.2, U6.6 (-)
/Shutdown_VCU/Open_Threshold: R16.2, R17.1, U6.12 (+), U7.10 (+), U11.3 (+)
/Shutdown_VCU/Rear_Brake_Open: U7.8, U12.10
/Shutdown_VCU/Rear_Brake_Short: U7.14, U12.9
/Shutdown_VCU/Short_Threshold: R15.1, R16.1, U6.9 (-), U7.13 (-), U11.6 (-)
/Shutdown_VCU/nBSPD_Fault: U10.13, U13.12
BSPD_Shutdown_Out: K3.5; also elsewhere on the board
Current_Analog_Buff_Filtered: R2.1, U6.10 (+), U6.13 (-), U8.1, U8.2 (-)
Current_Sensor_Fault: U9.1, U12.6; also elsewhere on the board
Current_Vref_Buff_Filtered: R1.1, U8.6 (-), U8.7
Front_Brake_Buff_Filtered: U7.3 (+), U8.13 (-), U8.14, U11.2 (-), U11.5 (+); also elsewhere on the board
Front_Brake_Fault: U9.5, U12.11; also elsewhere on the board
GND: C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.1, D22.2 (A), K3.1, R3.1, R4.1, R5.1, R6.1, R7.1, R14.1, R17.2, R20.1, RV1.3, RV2.3, U4.2 (GND), U5.2 (GND), U6.11 (V-), U7.11 (V-), U8.11 (V-), U9.7 (GND), U11.11 (V-), U12.7 (GND), U14.1, U14.4; also elsewhere on the board
Hard_Braking_High_Current: U9.9, U10.6; also elsewhere on the board
Inertia_Shutdown: K3.8, SW3.2 (B); also elsewhere on the board
unnamed: C16.2, D1.2 (A), R18.1, U11.10 (+)
unnamed: D22.1 (K), K2.8, K3.2
unnamed: K2.7, U14.3
unnamed: K2.12, U14.6
unnamed: SW1.2 (B), SW2.1 (A)
unnamed: SW2.2 (B), SW3.1 (A)
unnamed: R2.2, R3.2, U6.3 (+)
unnamed: R1.2, R8.1, U6.2 (-)
unnamed: RV2.2, U7.2 (-)
unnamed: RV1.2, U7.6 (-)
unnamed: C9.1, R11.2, U8.3 (+)
unnamed: C8.1, R12.2, U8.5 (+)
unnamed: C6.1, R9.2, U8.10 (+)
unnamed: C7.1, R10.1, U8.12 (+)
unnamed: U9.2, U9.6
Rear_Brake_Buff_Filtered: U7.5 (+), U7.9 (-), U7.12 (+), U8.8, U8.9 (-); also elsewhere on the board
Rear_Brake_Fault: U9.4, U12.8; also elsewhere on the board

Notes on the sheet:
1/(2π*10000*.015*10^-6) = 106.10 HZ
Power Supply
Current Sensor Max: 4.375 V 2.5 +(900/300 * 0.625)
Gain: 20 Max Voltage Output (analog): 2.596 V Max Dif Output: 1.929 V
Power: 5000 W Nominal Voltage: 108 V Nominal Current: 46.296 A
106.10 HZ Cutoff
Adjustable Reference
1/(2π*10000*1.8*10^-9) = 8841.94 HZ
8841.94 HZ Cutoff
5 * (12k/(12k + 19.1k) = 1.929 V
BSPD Latching Relay
5(10k/(10k + 5.23k) = 3.298 V
Current + Brake Sensor Buffers + Filters
.464 Second Delay 3.3 = 5(1-e^(t/(RC)) 1.079 * RC = t t = 0.464 s
BSPD Sensor Short/Open
2.5 + 0.625(46.296/300) = 2.59645 V Analog
4.736*(10k)/(9.53k+171k) = 0.262 V
Brake Sensor Max: 4.5 Brake Sensor Min: 0.5
Current Sensor Min: 0.625 V 2.5 +(-900/300 * 0.625)
Bots + Inertia Switch + E-Stop
5*(171k)/(9.53k+171k) = 4.736 V
BSPD High Current + Hard Braking
PWR Not On VCU

Parts:
C23: 220nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB224; Digi PN 311-1803-1-ND
C25, C26, C33, C34, C40, C43, C44, C45, C46, C48, C49: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603JRX7R9BB104; Digi PN 311-1779-1-ND
C27, C28, C29, C30: 39nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603JRX7R9BB393; Digi PN 13-CC0603JRX7R9BB393CT-ND
C35, C36, C39, C41: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CL10A475KL8NRNC; Digi PN 1276-6794-1-ND
C37, C38: 6.8pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603DRNPO9BN6R8; Digi PN 311-3874-1-ND
C42: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CL10A106KO8NQNC; Digi PN 1276-CL10A106KO8NQNCCT-ND
C47: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603JRX7R6BB105; Digi PN 311-3484-1-ND
D19: LTST-S270KRKT; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MFG PN LTST-S270KRKT; Digi PN 160-1479-1-ND
D20: 1092QD5-12V; MFG PN 1092QD5-12V; Digi PN 1092QD5-12V-ND; not fitted
D21: 12V-SB-RED-12M; MFG PN 12V-SB-RED-12M; Digi PN 1647-12V-SB-RED-12MCT-ND; not fitted
D24: PMEG10020ELR; Nexperia_CFP3_SOD-123W; MFG PN PMEG10020ELR-QX; Digi PN 1727-PMEG10020ELR-QXCT-ND
FB1: FCM 1608KF-601T03; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MFG PN FCM 1608KF-601T03; Digi PN 4816-FCM1608KF-601T03CT-ND
J4: FTSH-107-01-F-DV-K-P-TR; PinHeader_2x07_P1.27mm_Vertical_SMD; MFG PN FTSH-107-01-F-DV-K-P-TR; Digi PN SAM13170CT-ND
LS1: CPT-1625-80-SMT-TR; MFG PN AI-3238-TF-LW140-R; Digi PN 668-1277-ND; not fitted
Q7, Q8, Q9, Q10: AO3400A; SOT-23; MFG PN AO3400A; Digi PN 785-1000-1-ND
R53, R54, R64, R65, R68, R75, R76, R87, R90: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-13100KL; Digi PN 13-AC0603FR-13100KLCT-ND
R55, R58, R59, R91: 12k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-1012KL; Digi PN 13-AC0603FR-1012KLCT-ND
R56, R57, R60, R81, R85, R92: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-0720KL; Digi PN YAG3577CT-ND
R61, R74, R77, R78: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-071KL; Digi PN 311-1.00KHRCT-ND
R62: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07120RL; Digi PN YAG3563CT-ND; not fitted
R63: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07120RL; Digi PN YAG3563CT-ND
R66, R67, R70: 300k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07300KL; Digi PN 13-AC0603FR-07300KLCT-ND
R69, R79: 300; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07300RL; Digi PN YAG5330CT-ND
R73, R80, R82, R83, R86: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-0710KL; Digi PN 311-10KLDCT-ND
R84: 36k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-0736KL; Digi PN 13-AC0603FR-0736KLCT-ND
R88: 200k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07200KL; Digi PN YAG3575CT-ND
RV3: Steering Position Sensor; MFG PN Steering Sensor; not fitted
SW4: PV1H240BB; SW_SPST_PTS647_Sx38; MFG PN PV1H240BB; Digi PN EG5277-ND; not fitted
SW5: Y97KT23B5NAFP; SW_SPST_PTS647_Sx38; MFG PN Y97KT23B5NAFP; Digi PN 108-Y97KT23B5NAFPCT-ND
TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP21: TestPoint; TestPoint_Pad_D1.0mm
U17, U18, U19: PST360G2; MFG PN PST360G2-1A-C0000-ERA360-05K; Digi PN 1993-1011-ND; not fitted
U21, U22: ISO1044BD; SOIC-8_ISO1044BD; MFG PN ISO1044BDR; Digi PN 296-ISO1044BDRCT-ND
U24: MCP6004; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN MCP6004T-I/SL; Digi PN MCP6004T-I/SLCT-ND
U25: 104990302; MFG PN 104990302; Digi PN 1597-1485-ND; not fitted
U26: STLINK-V3MODS; MODULE_STLINK-V3MODS; PARTREV 1; Digi PN 497-STLINK-V3MODS-ND
U27: STM32F446RETx; LQFP-64_10x10mm_P0.5mm; MFG PN STM32F446RET6; Digi PN 497-15376-ND
Y1: ECS-240-8-37B-CKY-TR; Crystal_SMD_2016-4Pin_2.0x1.6mm; MFG PN ECS-240-8-37B-CKY-TR; Digi PN XC3063CT-ND

Connections:
+3V3: C25.1, C26.1, C42.2, C43.1, C44.1, C45.1, C46.1, FB1.1, J4.3, SW4.2, U21.1 (VCC1), U22.1 (VCC1), U26.30 (T_VCC), U27.1 (VBAT), U27.19 (VDD), U27.32 (VDD), U27.48 (VDD), U27.64 (VDD); also elsewhere on the board
+3V3A: C47.1, C48.1, FB1.2, U27.13 (VDDA)
+5V: C33.1, C34.1, C49.1, R79.2, RV3.1, U17.1 (PWR), U18.1 (PWR), U19.1 (PWR), U21.8 (VCC2), U22.8 (VCC2), U24.4 (V+), U25.1 (VDD), U26.22 (5V_OPT); also elsewhere on the board
/APPS_1_Raw: U17.3 (Out1), U24.10 (+); also elsewhere on the board
/APPS_2_Raw: U18.3 (Out1), U24.12 (+); also elsewhere on the board
/BPPS_1_Raw: U19.3 (Out1), U24.3 (+); also elsewhere on the board
/Brake_LED_Cathode: D21.1 (K), Q9.3 (D); also elsewhere on the board
/CAN_Powertrain_H: R63.2, U21.6 (CANH); also elsewhere on the board
/CAN_Powertrain_L: R63.1, U21.5 (CANL); also elsewhere on the board
/Dash_Lap: R65.1, R67.2; also elsewhere on the board
/Dash_Launch: R64.1, R66.2; also elsewhere on the board
/Driverless_Signal: R68.1, R70.2; also elsewhere on the board
/MCU/BOOT0: R73.1, U27.60 (BOOT0)
/MCU/BOOT1: R80.1, U27.28 (PB2)
/MCU/BSDP_Fault: R87.1; also elsewhere on the board
/MCU/BSPD_Fault_3V3: R87.2, R88.1, U27.16 (PA2)
/MCU/BSPD_Shutdown_Out_3V04: R82.1, R84.2, U27.17 (ADC1_IN3)
/MCU/Front_Brake_Buff_Filtered_3V: R85.2, R86.2, U27.15 (ADC1_IN1)
/MCU/OSC_IN: C37.1, U27.5 (RCC_OSC_IN), Y1.3
/MCU/OSC_OUT: C38.1, U27.6 (RCC_OSC_OUT), Y1.1
/MCU/Rear_Brake_Buff_Filtered_3V: R81.2, R83.2, U27.14 (ADC1_IN0)
/MCU/SPS_1_Raw: RV3.2, U24.5 (+); also elsewhere on the board
/MCU/Solenoid_Neg: D24.1 (K), Q10.3 (D); also elsewhere on the board
/RTD_Button_Neg: R53.1, R54.1, SW4.1; also elsewhere on the board
/RTD_Buzzer_Neg: LS1.N, Q8.3 (D); also elsewhere on the board
/RTD_Buzzer_Pos: LS1.P, R79.1; also elsewhere on the board
/RTD_LED_Cathode: D20.1 (K), Q7.3 (D); also elsewhere on the board
/Status_Indicator_Strip: U25.4 (DIN), U27.3 (PC14); also elsewhere on the board
/UART5_RX: U27.54 (UART5_RX); also elsewhere on the board
/UART5_TX: U27.53 (UART5_TX); also elsewhere on the board
APPS_1_Buff_Filt: C28.1, R55.1, R56.1, U27.9 (ADC1_IN11)
APPS_2_Buff_Filt: C29.1, R57.2, R58.2, U27.10 (ADC1_IN12)
BME_NSS: U27.56 (SPI2_NSS); also elsewhere on the board
BNO_BOOTN: U27.40 (PC9); also elsewhere on the board
BNO_NRST: U27.39 (PC8); also elsewhere on the board
BPPS_1_Buff_Filt: C30.1, R59.1, R60.1, U27.11 (ADC1_IN13)
BSPD_Shutdown_Out: R84.1; also elsewhere on the board
Brake_Light_Signal: R76.2, R78.1, U27.24 (PC4)
CAN_Data_H: R62.2, U22.6 (CANH); also elsewhere on the board
CAN_Data_L: R62.1, U22.5 (CANL); also elsewhere on the board
CAN_Data_RX: U22.3 (RXD), U27.57 (CAN2_RX)
CAN_Data_TX: U22.2 (TXD), U27.58 (CAN2_TX)
CAN_Powertrain_RX: U21.3 (RXD), U27.61 (CAN1_RX)
CAN_Powertrain_TX: U21.2 (TXD), U27.62 (CAN1_TX)
Dash_Lap_Filtered: C36.1, R67.1, U27.21 (PA5)
Dash_Launch_Filtered: C35.1, R66.1, U27.20 (PA4)
Driverless_Signal_Filtered: C39.1, R70.1, U27.22 (PA6)
Front_Brake_Buff_Filtered: R86.1; also elsewhere on the board
GND: C23.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.1, C41.1, C42.1, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, D19.1 (K), D24.2 (A), J4.5, J4.7, J4.11, Q7.2 (S), Q8.2 (S), Q9.2 (S), Q10.2 (S), R53.2, R56.2, R58.1, R60.2, R64.2, R65.2, R68.2, R73.2, R75.1, R76.1, R80.2, R81.1, R82.2, R85.1, R88.2, R90.1, R92.2, RV3.3, SW5.1, U17.2 (GND), U18.2 (GND), U19.2 (GND), U21.4 (GND1), U21.7 (GND2), U22.4 (GND1), U22.7 (GND2), U24.11 (V-), U25.2 (VSS), U25.3 (BIN), U26.5 (GNDDETECT), U26.8 (GND_2), U26.24 (GND), U26.26 (GND2), U26.27 (GND3), U26.29 (GND4), U27.12 (VSSA), U27.18 (VSS), U27.31 (VSS), U27.47 (VSS), U27.63 (VSS), Y1.2, Y1.4; also elsewhere on the board
INT1_3V3: U27.34 (PB13); also elsewhere on the board
NRST: C40.2, J4.12, SW5.2, U26.31 (T_NRST), U27.7 (NRST)
unnamed: D19.2 (A), R69.1
unnamed: D20.2 (A), D21.2 (A)
unnamed: Q7.1 (G), R61.1
unnamed: Q8.1 (G), R77.2
unnamed: Q9.1 (G), R78.2
unnamed: Q10.1 (G), R74.1
unnamed: R59.2, U24.1, U24.2 (-)
unnamed: R91.2, U24.6 (-), U24.7
unnamed: R55.2, U24.8, U24.9 (-)
unnamed: R57.1, U24.13 (-), U24.14
unnamed: TP11.1, U27.41 (PA8)
unnamed: TP12.1, U27.42 (PA9)
unnamed: TP13.1, U27.43 (PA10)
unnamed: TP21.1, U27.45 (PA12)
unnamed: TP17.1, U27.50 (PA15)
unnamed: TP14.1, U27.26 (PB0)
unnamed: TP18.1, U27.59 (PB7)
unnamed: TP15.1, U27.29 (PB10)
unnamed: TP16.1, U27.4 (PC15)
unnamed: C41.2, U27.30 (VCAP_1)
RTD_Button_3V3: C27.1, R54.2, U27.2 (PC13)
RTD_Buzzer: R75.2, R77.1, U27.23 (PA7)
RTD_LED: R61.2, R69.2, U27.8 (PC0)
Rear_Brake_Buff_Filtered: R83.1; also elsewhere on the board
SPI2_MISO: U27.35 (SPI2_MISO); also elsewhere on the board
SPI2_MOSI: U27.36 (SPI2_MOSI); also elsewhere on the board
SPI2_NSS: U27.33 (SPI2_NSS); also elsewhere on the board
SPI2_SCK: U27.38 (SPI2_SCK); also elsewhere on the board
SPS_1_Buff_Filt: C23.1, R91.1, R92.1, U27.25 (PC5)
STLINK_SWCLK: J4.6, U26.13 (T_JCLK/T_SWCLK), U27.49 (SYS_JTCK-SWCLK)
STLINK_SWDIO: J4.4, U26.4 (T_JTMS/T_SWDIO), U27.46 (SYS_JTMS-SWDIO)
STLINK_SWO: J4.8, U26.6 (T_JTDO/T_SWO), U27.55 (SYS_JTDO-SWO)
Solenoid_Signal: R74.2, R90.2, U27.27 (PB1)
UART4_RX: J4.13, U26.15 (T_VCP_RX), U27.52 (UART4_RX)
UART4_TX: J4.14, U26.12 (T_VCP_TX), U27.51 (UART4_TX)
WKUP1: U27.44 (PA11); also elsewhere on the board

Notes on the sheet:
3.3V
(12k + 20k)/(2π*12k*20k*39*10^-9) = 544.119 HZ
1/(2pi*100000*40*10^-9) = 39.79 HZ
STLINKV3-MODS Programmer
RED LED STRIP
0-3.125 V
0-1.875 V
Dash Pins
CAN Tranceiver
Brake Light Logic
4.5 V
5V Max
0-3.0 V Analog
Green
ST-Link Programming/Debugging Connector
(12k + 20k)/(2π*12k*20k*220*10^-9) = 96.458 HZ
Regenerative Braking Solenoid
NOTE: CAN Bridge left disconnected for now, but if we can figure out the protocol on the usb side to access it, we can connect it
79.98 DBA at 2m (Cole Wanted Quieter) 3,800 ± 500 Hz Resonant Frequency
1/(2pi*300000*4.7*10^-9) = 112.88 HZ
5V Max
APPS + BPPS Buffer + Filter
5 V
Power Supply
14V
Gain: 0.217 * Voltage input 0 to 3.04V Max given 14v input
Microcontroller

Parts:
C17, C18, C19, C21, C22: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603JRX7R9BB104; Digi PN 311-1779-1-ND
C20: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603JRX7R6BB105; Digi PN 311-3484-1-ND
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11: LTST-S270KRKT; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MFG PN LTST-S270KRKT; Digi PN 160-1479-1-ND
D12, D13: 1092QD1-12V-ND; MFG PN 1092QD1-12V; Digi PN 1092QD1-12V-ND; not fitted
D14, D16: PCL2212V100B; MFG PN PCL2212V100B; Digi PN PCL2212V100B-ND; not fitted
D15, D17: PCL2212V500B; MFG PN PCL2212V500B; Digi PN PCL2212V500B-ND; not fitted
D18: 1092QD3-12V; MFG PN 1092QD3-12V; Digi PN 1092QD3-12V-ND; not fitted
Q1, Q2, Q3, Q4, Q5: AO3400A; SOT-23; MFG PN AO3400A; Digi PN 785-1000-1-ND
R21, R22, R23, R28, R29, R30, R31, R38, R39, R40: 300; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07300RL; Digi PN YAG5330CT-ND
R24, R26, R32, R34, R36: 200k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07200KL; Digi PN YAG3575CT-ND
R25, R27, R33, R35, R37, R41, R42, R47, R48, R51: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-13100KL; Digi PN 13-AC0603FR-13100KLCT-ND
R43, R44, R49, R50, R52: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-071KL; Digi PN 311-1.00KHRCT-ND
R45: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-0710KL; Digi PN 311-10KLDCT-ND
R46: 220k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07220KL; Digi PN YAG3579CT-ND
TP3: BOTS_Shutdown; TestPoint_Pad_D1.0mm
TP4: Inertia_Shutdown; TestPoint_Pad_D1.0mm
TP5: Shutdown_In; TestPoint_Pad_D1.0mm
TP6: E_Stop_Shutdown; TestPoint_Pad_D1.0mm
TP7: BSPD_Shutdown_Out; TestPoint_Pad_D1.0mm
TP8: TSSI_Status; TestPoint_Pad_D1.0mm
TP9: TSSI_Red_Logic; TestPoint_Pad_D1.0mm
U10: SN74HCS08DR; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN SN74HCS08DR; Digi PN 296-SN74HCS08DRCT-ND
U13, U15: SN74HC14DR; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN SN74HC14DR; Digi PN 296-1194-1-ND
U16: LM555CMX; SOIC-8_3.9x4.9mm_P1.27mm; MFG PN LM555CMX/NOPB; Digi PN LM555CMX/NOPBCT-ND

Connections:
+5V: C17.1, C18.1, C19.1, C22.1, R45.1, U10.14 (VCC), U13.14 (VCC), U15.14 (VCC), U16.8 (VCC); also elsewhere on the board
/BMS_LED_Cathode: D13.1 (K), Q1.3 (D); also elsewhere on the board
/BSPD_LED_Cathode: D18.1 (K), Q5.3 (D); also elsewhere on the board
/IMD_LED_Cathode: D12.1 (K), Q2.3 (D); also elsewhere on the board
/MCU/BSDP_Fault: R21.2, R51.2, R52.2; also elsewhere on the board
/Shutdown_VCU/Shutdown_LEDS/5v_Oscillation: R48.2, R50.2, U16.3 (Q)
/Shutdown_VCU/Shutdown_LEDS/TSSI_Red_Logic: TP9.1, U13.6, U16.4 (R)
/Shutdown_VCU/Shutdown_LEDS/TSSI_Status: R47.2, R49.2, TP8.1, U10.8, U13.5
/TSSI_GREEN_Cathode: D15.1 (K), D17.1 (K), Q3.3 (D); also elsewhere on the board
/TSSI_RED_Cathode: D14.1 (K), D16.1 (K), Q4.3 (D); also elsewhere on the board
/nBMS_Fault: U10.10, U13.9; also elsewhere on the board
/nIMD_Fault: U10.9, U13.11; also elsewhere on the board
BOTS_Shutdown: R24.1, TP3.1; also elsewhere on the board
BSPD_Shutdown_Out: R36.1, TP7.1; also elsewhere on the board
Current_Sensor_Fault: R31.2; also elsewhere on the board
E_Stop_Shutdown: R34.1, TP6.1; also elsewhere on the board
Front_Brake_Fault: R30.2; also elsewhere on the board
GND: C17.2, C18.2, C19.2, C20.1, C21.1, C22.2, D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), R25.2, R27.2, R33.2, R35.2, R37.2, R41.1, R42.1, R47.1, R48.1, R51.1, U10.7 (GND), U13.7 (GND), U15.7 (GND), U16.1 (GND); also elsewhere on the board
Hard_Braking_High_Current: R23.2; also elsewhere on the board
Inertia_Shutdown: R26.1, TP4.1; also elsewhere on the board
unnamed: D2.2 (A), R21.1
unnamed: D3.2 (A), R22.2
unnamed: D4.2 (A), R23.1
unnamed: D5.2 (A), R28.1
unnamed: D6.2 (A), R29.1
unnamed: D7.2 (A), R30.1
unnamed: D8.2 (A), R31.1
unnamed: D9.2 (A), R38.1
unnamed: D10.2 (A), R39.1
unnamed: D11.2 (A), R40.1
unnamed: D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A)
unnamed: Q1.1 (G), R43.1
unnamed: Q2.1 (G), R44.1
unnamed: Q3.1 (G), R49.1
unnamed: Q4.1 (G), R50.1
unnamed: Q5.1 (G), R52.1
unnamed: R24.2, R25.1, U15.11
unnamed: R26.2, R27.1, U15.3
unnamed: R28.2, U15.10
unnamed: R29.2, U15.4
unnamed: R32.2, R33.1, U15.9
unnamed: R34.2, R35.1, U15.5
unnamed: R36.2, R37.1, U15.1
unnamed: R38.2, U15.8
unnamed: R39.2, U15.6
unnamed: R40.2, U15.2
unnamed: R41.2, R43.2, U13.8
unnamed: R42.2, R44.2, U13.10
unnamed: C21.2, U16.5 (CV)
unnamed: R45.2, R46.2, U16.7 (DIS)
unnamed: C20.2, R46.1, U16.2 (TR), U16.6 (THR)
Rear_Brake_Fault: R22.1; also elsewhere on the board
Shutdown_In: R32.1, TP5.1; also elsewhere on the board

Notes on the sheet:
4V Input
12V
RED LED
~3.2 Hz 53% Duty Cycle Time High: 159.39ms Time Low: 152.46 Falstad: https://tinyurl.com/2b3ys44g
BSPD Fault Lights
Shutdown Circuit Node + Car Status
Power Supply
GREEN LED
AMBER LED
Tractive System Status Indicator
100mA Max (Combined)
100mA Max (Combined)
Dash LED Drivers
